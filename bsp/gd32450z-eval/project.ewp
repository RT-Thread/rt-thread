# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: GD32F450xK GD GD32F450xK
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32F4XX; USE_STDPERIPH_DRIVER; GD32F4XX
  ICCARM.CCIncludePath2: ..\..\..\git\rt-thread\components\net\lwip-1.4.1\src; ..\..\..\git\rt-thread\libcpu\arm\cortex-m4; ..\..\..\git\rt-thread\components\net\lwip-1.4.1\src\include; ..\..\..\git\rt-thread\components\trace; ..\..\..\git\rt-thread\include; ..\..\..\git\rt-thread\components\net\lwip-1.4.1\src\arch\include; ..\..\..\git\rt-thread\components\trace\SystemView_Src_V240\SEGGER; drivers; ..\..\..\git\rt-thread\components\net\lwip-1.4.1\src\include\ipv4; ..\..\..\git\rt-thread\components\net\lwip-1.4.1\src\include\netif; Libraries\GD32F4xx_standard_peripheral\Include; .; applications; ..\..\..\git\rt-thread\components\finsh; Libraries\CMSIS; ..\..\..\git\rt-thread\components\drivers\spi; ..\..\..\git\rt-thread\components\trace\SystemView_Src_V240\Config; ..\..\..\git\rt-thread\components\drivers\include; ..\..\..\git\rt-thread\libcpu\arm\common; Libraries\CMSIS\GD\GD32F4xx\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: project.srec
  ILINK.IlinkOutputFile: GD32F450Z_EVAL.out
  ILINK.IlinkIcfFile: gd32_rom.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; USE_STDPERIPH_DRIVER; GD32F4XX
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: application.c benchmark.c device_test.c mem_test.c ping.c rtgui_demo.c startup.c
  group Drivers
    drivers/: board.c drv_exmc_sdram.c drv_usart.c gd32f450z_lcd_eval.c drv_lcd.c drv_enet.c synopsys_emac.c
  group GD32_Lib
    Libraries/GD32F4xx_standard_peripheral/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
    Libraries/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
    Libraries/CMSIS/GD/GD32F4xx/Source/IAR/: startup_gd32f4xx.s
  group Kernel
    ../../../git/rt-thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c module.c object.c scheduler.c thread.c timer.c
  group CORTEX-M4
    ../../../git/rt-thread/libcpu/arm/cortex-m4/: cpuport.c context_iar.S
    ../../../git/rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
  group DeviceDrivers
    ../../../git/rt-thread/components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    ../../../git/rt-thread/components/drivers/serial/: serial.c
    ../../../git/rt-thread/components/drivers/spi/: spi_core.c spi_dev.c
    ../../../git/rt-thread/components/drivers/src/: completion.c dataqueue.c pipe.c portal.c ringbuffer.c workqueue.c
  group finsh
    ../../../git/rt-thread/components/finsh/: shell.c symbol.c cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_var.c finsh_vm.c finsh_token.c
  group LwIP
    ../../../git/rt-thread/components/net/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../git/rt-thread/components/net/lwip-1.4.1/src/arch/: sys_arch.c
    ../../../git/rt-thread/components/net/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../../../git/rt-thread/components/net/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../../git/rt-thread/components/net/lwip-1.4.1/src/netif/: etharp.c ethernetif.c slipif.c
  group trace
    ../../../git/rt-thread/components/trace/SystemView_Src_V240/Config/: SEGGER_SYSVIEW_Config_RTThread.c SEGGER_SYSVIEW_RTThread.c
    ../../../git/rt-thread/components/trace/SystemView_Src_V240/SEGGER/: SEGGER_RTT.c SEGGER_SYSVIEW.c
