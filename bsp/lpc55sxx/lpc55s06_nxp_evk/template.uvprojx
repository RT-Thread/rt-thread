# Keil uVision project template.uvprojx, settings and files
target rtthread-lpc55s06 (6160000::V6.16::ARMCLANG)
  device: LPC55S06JBD64 NXP
  pack: NXP.LPC55S06_DFP.14.0.0
  cpu: IRAM(0x10000000,0x03d800) IRAM2(0x20000000,0x010000) IROM(0x03000000,0x020000) IROM2(0x13000000,0x020000) XRAM(0x30000000,0x010000) XRAM2(0x20010000,0x4000) XRAM3(0x30010000,0x4000) XROM(0x00000000,0x03d800) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: rtthread +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=3
  c define: CPU_LPC55S06JBD64, ARM_MATH_CM33,  RT_USING_ARM_LIBC
  c misc: --target=arm-arm-none-eabi
  asm misc: -x assembler-with-cpp
  memory RVCT1: ROM 0x0 size 0x3d800
  memory RVCT4: ROM 0x3000000 size 0x20000
  memory RVCT5: ROM 0x13000000 size 0x20000
  memory RVCT6: RAM 0x30000000 size 0x10000
  memory RVCT7: RAM 0x20010000 size 0x4000
  memory RVCT8: RAM 0x30010000 size 0x4000
  memory RVCT9: RAM 0x10000000 size 0x3d800
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: .\board\linker_scripts\LPC55S06_flash.scf
  link misc: --keep *.o(.rti_fn.*)   --keep *.o(FSymTab) --keep *.o(VSymTab)
