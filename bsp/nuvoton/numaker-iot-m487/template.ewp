# IAR project template.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M481AE series Nuvoton M481AE series (M481AE,M482AE,M483AE,M485AE,M487AE)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: rtthread.bin
  ILINK.IlinkOutputFile: Template.out
  ILINK.IlinkIcfFile: linking_scripts\m480_flash.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
