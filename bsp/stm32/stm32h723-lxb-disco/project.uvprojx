# Keil uVision project project.uvprojx, settings and files
target rtthread (6230000::V6.23::ARMCLANG)
  device: STM32H723ZGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.2
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00050000) IROM(0x08000000,0x00100000) XRAM(0x30000000,0x00008000) XRAM2(0x38000000,0x00004000) CPUTYPE("Cortex-M7") FPU3(DFPU) DSP CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER, __RTTHREAD__, RT_USING_ARMLIBC, STM32H723xx, __STDC_LIMIT_MACROS, __CLK_TCK=RT_TICK_PER_SECOND, RT_USING_LIBC
  c include: packages\stm32h7_cmsis_driver-latest\Include;..\libraries\HAL_Drivers;packages\CMSIS-Core-latest\Include;..\..\..\components\libc\compilers\common\extension;..\..\..\libcpu\arm\common;..\..\..\components\libc\posix\io\eventfd;..\..\..\components\libc\compilers\common\include;..\libraries\HAL_Drivers\drivers;..\..\..\components\libc\posix\io\poll;..\..\..\components\drivers\smp_call;..\..\..\components\net\utest;applications;..\..\..\components\drivers\phy;..\..\..\components\drivers\include;..\libraries\HAL_Drivers\drivers\config;..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\components\drivers\include;board;..\..\..\components\libc\posix\io\epoll;packages\stm32h7_hal_driver-latest\Inc\Legacy;..\..\..\components\drivers\include;packages\stm32h7_hal_driver-latest\Inc;..\..\..\components\drivers\include;.;..\..\..\components\drivers\include;..\..\..\libcpu\arm\cortex-m7;..\..\..\components\finsh;..\..\..\components\libc\posix\ipc;..\..\..\include;board\CubeMX_Config\Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT6: RAM 0x30000000 size 0x8000
  memory RVCT7: RAM 0x38000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x50000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/pin/: dev_pin.c
    ../../../components/drivers/serial/: dev_serial.c
  group Drivers
    ../libraries/HAL_Drivers/drivers/: drv_gpio.c drv_usart.c
    ../libraries/HAL_Drivers/: drv_common.c
    board/CubeMX_Config/Src/: stm32h7xx_hal_msp.c
    board/: board.c
  group Finsh
    ../../../components/finsh/: shell.c msh_parse.c msh.c cmd.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    ../../../src/klibc/: rt_vsscanf.c kstring.c kerrno.c rt_vsnprintf_tiny.c kstdio.c
  group libcpu
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m7/: context_rvds.S cpu_cache.c cpuport.c
  group STM32H7-CMSIS
    packages/stm32h7_cmsis_driver-latest/Source/Templates/: system_stm32h7xx.c
    packages/stm32h7_cmsis_driver-latest/Source/Templates/arm/: startup_stm32h723xx.s
  group STM32H7-HAL
    packages/stm32h7_hal_driver-latest/Src/: stm32h7xx_hal_dma_ex.c stm32h7xx_hal_pwr.c stm32h7xx_hal_mdma.c stm32h7xx_hal_dma.c stm32h7xx_hal_cortex.c stm32h7xx_hal_cryp_ex.c stm32h7xx_hal_cryp.c stm32h7xx_hal_sram.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_comp.c stm32h7xx_hal_cec.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_usart.c stm32h7xx_hal_rng.c stm32h7xx_hal_rcc.c stm32h7xx_hal_gpio.c stm32h7xx_hal_crc.c
