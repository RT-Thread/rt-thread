# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: NUC472HI8AE Nuvoton NUC472HI8AE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: Libraries\CMSIS\Include; ..\..\include; drivers; .; applications; ..\..\libcpu\arm\cortex-m4; ..\..\components\drivers\include; ..\..\libcpu\arm\common; Libraries\StdDriver\inc; ..\..\components\finsh; Libraries\Device\Nuvoton\NUC472_442\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: nuc472_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: application.c
  group Drivers
    drivers/: board.c usart.c
  group CMSIS
    Libraries/Device/Nuvoton/NUC472_442/Source/: system_NUC472_442.c
    Libraries/Device/Nuvoton/NUC472_442/Source/IAR/: startup_NUC472_442.s
  group NUC472_StdPeriph
    Libraries/StdDriver/src/: acmp.c adc.c can.c cap.c clk.c crc.c crypto.c eadc.c ebi.c emac.c epwm.c fmc.c gpio.c i2c.c i2s.c pdma.c ps2.c pwm.c rtc.c sc.c scuart.c sd.c spi.c sys.c timer_.c uart.c usbd.c wdt.c wwdt.c
  group Kernel
    ../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group CORTEX-M4
    ../../libcpu/arm/cortex-m4/: cpuport.c context_iar.S
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
  group DeviceDrivers
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/src/: completion.c dataqueue.c pipe.c ringbuffer.c waitqueue.c workqueue.c
  group finsh
    ../../components/finsh/: shell.c symbol.c cmd.c msh.c msh_cmd.c msh_file.c
