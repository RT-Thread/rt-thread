# Keil uVision project libStdDriver.uvprojx, settings and files
target libstddriver-m031 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: M032KIAAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.10
  cpu: IRAM(0x20000000,0x18000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: libstddriver_keil +hex (library)
  AfterMake: xcopy /y ".\build\keil5\@L.lib" "."
  c flags: Optim=1 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=2
  c include: ..\inc;..\..\CMSIS\Include;..\..\Device\Nuvoton\M031\Include;.
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group src
    ../src/: nu_acmp.c nu_adc.c nu_bpwm.c nu_clk.c nu_crc.c nu_ebi.c nu_fmc.c nu_gpio.c nu_i2c.c nu_pdma.c nu_pwm.c nu_qspi.c nu_rtc.c nu_spi.c nu_sys.c nu_timer.c nu_uart.c nu_usbd.c nu_usci_i2c.c nu_usci_spi.c nu_usci_uart.c nu_wdt.c nu_wwdt.c
