# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: R9A07G075M24_CPU0 Renesas R9A07G075M24_CPU0
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 49
  General.FPU2: 8
  ICCARM.CCDefines: _RENESAS_RZT_; _RZT_CORE=CR52_0; _RZT_ORDINAL=1; __RTTHREAD__; CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; __RT_IPC_SOURCE__; __RT_KERNEL_SOURCE__
  ICCARM.CCIncludePath2: rzt/arm/CMSIS_5/CMSIS/Core_R/Include; rzt/fsp/inc; rzt/fsp/inc/api; rzt/fsp/inc/instances; rzt/fsp/src/bsp/mcu/all/cr; rzt_cfg/fsp_cfg; rzt_cfg/fsp_cfg/bsp; rzt_gen; src; $PROJ_DIR$; .; ..\..\..\libcpu\arm\common; ..\..\..\libcpu\arm\cortex-r52; ..\..\..\components\drivers\include; ..\..\..\components\drivers\phy; ..\..\..\components\drivers\smp_call; board; board\ports; board\ports\wifi; ..\libraries\HAL_Drivers\drivers; ..\libraries\HAL_Drivers\drivers\config; ..\libraries\HAL_Drivers; ..\..\..\components\finsh; ..\..\..\include; ..\..\..\components\libc\compilers\common\include; ..\..\..\components\libc\compilers\common\extension; ..\..\..\components\libc\compilers\common\extension\fcntl\octal; ..\..\..\components\libc\posix\io\epoll; ..\..\..\components\libc\posix\io\eventfd; ..\..\..\components\libc\posix\io\poll; ..\..\..\components\libc\posix\ipc; ..\..\..\components\net\utest
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: _RENESAS_RZT_; _RZT_CORE=CR52_0; _RZT_ORDINAL=1
  AARM.AUserIncludes: rzt/arm/CMSIS_5/CMSIS/Core_R/Include; rzt/fsp/inc; rzt/fsp/inc/api; rzt/fsp/inc/instances; rzt/fsp/src/bsp/mcu/all/cr; rzt_cfg/fsp_cfg; rzt_cfg/fsp_cfg/bsp; rzt_gen; src; $PROJ_DIR$
  ILINK.IlinkOutputFile: template.out
  ILINK.IlinkIcfFile: script/fsp_xspi0_boot.icf
  ILINK.IlinkExtraOptions: --config_search "$PROJ_DIR$"
  ILINK.IlinkProgramEntryLabel: system_init
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; _RENESAS_RZT_; _RZT_CORE=CR52_0; _RZT_ORDINAL=1; __RTTHREAD__; CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; __RT_IPC_SOURCE__; __RT_KERNEL_SOURCE__
  ICCARM.CCOptLevel: 3
  ICCARM.IccLang: 0
  group (top)
    ./: buildinfo.ipcf
  group Flex Software/Build Configuration
    rzt_cfg/fsp_cfg/bsp/: board_cfg.h bsp_cfg.h bsp_mcu_device_cfg.h bsp_mcu_device_memory_cfg.h bsp_mcu_device_pn_cfg.h bsp_mcu_family_cfg.h bsp_memory_cfg.h bsp_pin_cfg.h
    rzt_cfg/fsp_cfg/: r_ioport_cfg.h r_sci_uart_cfg.h
  group Flex Software/Components
    rzt/board/rzt2m_rsk/: board.h board_ethernet_phy.h board_init.c board_init.h board_leds.c board_leds.h
    rzt/fsp/inc/api/: bsp_api.h r_ioport_api.h r_transfer_api.h r_uart_api.h
    rzt/fsp/src/bsp/mcu/all/: bsp_cache.c bsp_cache.h bsp_clocks.c bsp_clocks.h bsp_common.c bsp_common.h bsp_compiler_support.h bsp_delay.c bsp_delay.h bsp_exceptions.h bsp_io.c bsp_io.h bsp_irq.c bsp_irq.h bsp_mcu_api.h bsp_module_stop.h bsp_register_protection.c bsp_register_protection.h bsp_reset.c bsp_reset.h bsp_sbrk.c bsp_semaphore.c bsp_semaphore.h bsp_tfu.h
    rzt/fsp/src/bsp/mcu/all/cr/: bsp_cache_core.c bsp_cache_core.h bsp_delay_core.c bsp_delay_core.h bsp_irq_core.c bsp_irq_core.h
    rzt/fsp/src/bsp/mcu/rzt2m/: bsp_elc.h bsp_feature.h bsp_irq_sense.c bsp_loader_param.c bsp_mcu_info.h bsp_override.h
    rzt/arm/CMSIS_5/CMSIS/Core_R/Include/: cmsis_compiler.h cmsis_cp15.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cr52.h
    rzt/fsp/inc/: fsp_common_api.h fsp_features.h fsp_version.h
    rzt/arm/CMSIS_5/: LICENSE.txt
    rzt/fsp/src/bsp/cmsis/Device/RENESAS/Include/: R9A07G074.h R9A07G075.h renesas.h system.h
    rzt/fsp/src/r_ioport/: r_ioport.c
    rzt/fsp/inc/instances/: r_ioport.h r_sci_uart.h
    rzt/fsp/src/r_sci_uart/: r_sci_uart.c
    rzt/fsp/src/bsp/cmsis/Device/RENESAS/Source/: startup.c system.c
    rzt/fsp/src/bsp/cmsis/Device/RENESAS/Source/cr/: startup_core.c system_core.c
  group Flex Software/Generated Data
    rzt_gen/: bsp_clock_cfg.h common_data.c common_data.h hal_data.c hal_data.h main.c pin_data.c vector_data.c vector_data.h
  group Flex Software/Program Entry
    src/: hal_entry.c
  group CPU
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-r52/: backtrace.c context_iar.S cpuport.c gicv3.c interrupt.c stack.c start_iar.S trap.c vector_iar.S
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/pin/: dev_pin.c
    ../../../components/drivers/serial/: dev_serial_v2.c
  group Drivers
    ../libraries/HAL_Drivers/drivers/: drv_gpio.c drv_usart_v2.c
    ../libraries/HAL_Drivers/: drv_common.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group Libc
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
    ../../../src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
