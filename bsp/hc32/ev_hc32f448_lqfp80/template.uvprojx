# Keil uVision project template.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: HC32F448MCTI HDSC
  pack: HDSC.HC32F448.1.0.0
  cpu: IROM1(0x00000000,0x40000) IROM2(0x03000C00,0x400) IRAM1(0x1FFF8000,0x10000) IRAM2(0x200F0000,0x1000) CPUTYPE("Cortex-M4") FPU2 CLOCK(8000000) ESEL ELITTLE
  output: rt-thread +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x3000c00 size 0x400
  memory RVCT9: RAM 0x1fff8000 size 0x10000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  scatter file: .\board\linker_scripts\link.sct
