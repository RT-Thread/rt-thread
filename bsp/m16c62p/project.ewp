# IAR project project.ewp, settings and files
configuration Debug (M16C, debug)
  General.GData16HeapSize: 0x400
  General.GFarHeapSize: 0x400
  General.GData20HeapSize: 0x400
  General.GStackSize: 0x80
  General.GIStackSize: 0x40
  General.OGChipSelectMenu: M30627FHP M30627FHP
  ICCM16C.CCDiagSuppress: Pa050
  ICCM16C.newCCIncludePaths: ..\..\include; drivers; ..\..\libcpu\m16c\common; .; ..\..\libcpu\m16c\m16c62p; applications; ..\..\components\finsh
  ICCM16C.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  ICCM16C.IccLang: 0
  XLINK.XclFile: lnkm30627fhp.xcl
  XLINK.XlinkStackSize: 1
  XLINK.XlinkInterruptStackSize: 1
configuration Release (M16C)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  XLINK.XclFile: lnk0t.xcl
  group Applications
    applications/: application.c startup.c
  group Drivers
    drivers/: board.c bsp.c uart.c start_iar.asm vectors_iar.asm interrupts_iar.asm
  group Kernel
    ../../src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group M16C62P
    ../../libcpu/m16c/m16c62p/: cpuport.c context_iar.S
  group finsh
    ../../components/finsh/: shell.c symbol.c cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_var.c finsh_vm.c finsh_token.c
