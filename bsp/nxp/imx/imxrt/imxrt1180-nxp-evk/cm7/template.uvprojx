# Keil uVision project template.uvprojx, settings and files
target rtthread_ram (6220000::V6.22::ARMCLANG)
  device: MIMXRT1189CVM8C:cm7 NXP
  pack: NXP.MIMXRT1189_DFP.25.06.00
  cpu: IRAM(0x20484000,0x07c000) IRAM2(0x20500000,0x040000) IROM(0x00000000,0x028000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rtthread +hex
  c flags: Optim=5 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RELOC_VECTOR
  c misc: -xc -std=gnu99 -mimplicit-float
  asm misc: -x assembler-with-cpp
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x28000
  memory RVCT9: RAM 0x20484000 size 0x7c000
  memory RVCT10: RAM 0x20500000 size 0x40000
  scatter file: .\board\linker_scripts\MIMXRT1189xxxxx_cm7_ram.scf
  link misc: --legacyalign
target rtthread_hyperram (6220000::V6.22::ARMCLANG)
  device: MIMXRT1189CVM8C:cm7 NXP
  pack: NXP.MIMXRT1189_DFP.25.06.00
  cpu: as above
  output: rtthread +hex
  c flags: Optim=5 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RELOC_VECTOR
  c misc: -xc -std=gnu99 -mimplicit-float
  asm misc: -x assembler-with-cpp
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x28000
  memory RVCT9: RAM 0x20484000 size 0x7c000
  memory RVCT10: RAM 0x20500000 size 0x40000
  scatter file: .\board\linker_scripts\MIMXRT1189xxxxx_cm7_hyperram.scf
  link misc: --legacyalign
target rtthread_flexspi_nor (6220000::V6.22::ARMCLANG)
  device: MIMXRT1189CVM8C:cm7 NXP
  pack: NXP.MIMXRT1189_DFP.25.06.00
  cpu: as above
  output: rtthread +hex
  c flags: Optim=5 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RELOC_VECTOR
  c misc: -xc -std=gnu99 -mimplicit-float
  asm misc: -x assembler-with-cpp
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x28000
  memory RVCT9: RAM 0x20484000 size 0x7c000
  memory RVCT10: RAM 0x20500000 size 0x40000
  scatter file: .\board\linker_scripts\MIMXRT1189xxxxx_cm7_flexspi_nor.scf
  link misc: --legacyalign
target rtthread_flexspi_nor_industry (6220000::V6.22::ARMCLANG)
  device: MIMXRT1189CVM8C:cm7 NXP
  pack: NXP.MIMXRT1189_DFP.25.06.00
  cpu: as above
  output: rtthread +hex
  c flags: Optim=5 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RELOC_VECTOR
  c misc: -xc -std=gnu99 -mimplicit-float
  asm misc: -x assembler-with-cpp
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x28000
  memory RVCT9: RAM 0x20484000 size 0x7c000
  memory RVCT10: RAM 0x20500000 size 0x40000
  scatter file: .\board\linker_scripts\MIMXRT1189xxxxx_cm7_flexspi_nor_industry.scf
  link misc: --legacyalign
target rtthread_flexspi_nor_hyperram (6220000::V6.22::ARMCLANG)
  device: MIMXRT1189CVM8C:cm7 NXP
  pack: NXP.MIMXRT1189_DFP.25.06.00
  cpu: as above
  output: rtthread +hex
  c flags: Optim=5 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RELOC_VECTOR
  c misc: -xc -std=gnu99 -mimplicit-float
  asm misc: -x assembler-with-cpp
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x28000
  memory RVCT9: RAM 0x20484000 size 0x7c000
  memory RVCT10: RAM 0x20500000 size 0x40000
  scatter file: .\board\linker_scripts\MIMXRT1189xxxxx_cm7_flexspi_nor_hyperram.scf
  link misc: --legacyalign
target rtthread_ram_industry (6220000::V6.22::ARMCLANG)
  device: MIMXRT1189CVM8C:cm7 NXP
  pack: NXP.MIMXRT1189_DFP.25.06.00
  cpu: IRAM(0x20484000,0x07c000) IRAM2(0x20520000,0x018000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rtthread +hex
  c flags: Optim=5 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RELOC_VECTOR
  c misc: -xc -std=gnu99 -mimplicit-float
  asm misc: -x assembler-with-cpp
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20484000 size 0x7c000
  memory RVCT10: RAM 0x20520000 size 0x18000
  scatter file: .\board\linker_scripts\MIMXRT1189xxxxx_cm7_ram_industry.scf
  link misc: --legacyalign --predefine="-D__use_shmem__=1 -D__multicore__=1"
