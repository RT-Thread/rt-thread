# Keil uVision project project.uvproj, settings and files
target RT-Thread/AT91SAM7X256 (ARM-ADS)
  device: AT91SAM7X256 Atmel
  cpu: IRAM(0x200000-0x20FFFF) IROM(0x100000-0x13FFFF) CLOCK(18432000) CPUTYPE(ARM7TDMI)
  output: project
  c flags: Optim=1
  c define: __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND, RT_USING_LIBC, __STDC_LIMIT_MACROS, RT_USING_ARMLIBC
  c include: drivers;..\..\components\libc\compilers\common\include;..\..\components\libc\posix\ipc;..\..\components\finsh;..\..\components\drivers\phy;..\..\components\drivers\include;..\..\components\libc\posix\io\poll;..\..\components\libc\compilers\common\extension;.;..\..\components\libc\posix\io\eventfd;applications;..\..\components\drivers\include;..\..\components\drivers\smp_call;..\..\components\libc\posix\io\epoll;..\..\libcpu\arm\AT91SAM7X;..\..\components\drivers\include;..\..\components\drivers\include;..\..\include;..\..\libcpu\arm\common;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\net\utest;..\..\components\libc\compilers\common\extension\fcntl\octal
  memory RVCT4: ROM 0x100000 size 0x40000
  memory RVCT9: RAM 0x200000 size 0x10000
  group Applications
    applications/: application.c startup.c
  group CPU
    ../../libcpu/arm/AT91SAM7X/: context_rvds.S cpu.c interrupt.c stack.c start_rvds.S trap.c
    ../../libcpu/arm/common/: div0.c showmem.c
  group DeviceDrivers
    ../../components/drivers/core/: device.c
    ../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../components/drivers/pin/: dev_pin.c
    ../../components/drivers/serial/: dev_serial.c
  group Drivers
    drivers/: board.c serial.c
  group Finsh
    ../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group Libc
    ../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
