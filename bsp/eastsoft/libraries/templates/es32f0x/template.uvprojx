# Keil uVision project template.uvprojx, settings and files
target rt-thread_es32f065x (ARM-ADS)
  device: ES32F0654LT Eastsoft
  pack: Keil.ES32F033x_F065x_F093x_DFP.1.0.0
  cpu: IRAM(0x20000000,0x00008000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: rtthread-es32f065x +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
