# IAR project project.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M481AE series Nuvoton M481AE series (M481AE,M482AE,M483AE,M485AE,M487AE)
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: ARM_MATH_CM4; CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; _DLIB_FILE_DESCRIPTOR; __RTTHREAD__; __RT_IPC_SOURCE__; __RT_KERNEL_SOURCE__
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..\libraries\m460\CMSIS\Include; ..\..\..\components\drivers\sdio\sdhci\include; ..\..\..\components\net\lwip\port; ..\..\..\components\net\lwip\lwip-2.1.2\src\include; ..\..\..\components\libc\posix\io\epoll; ..\..\..\components\drivers\phy; ..\..\..\components\utilities\ulog; ..\..\..\include; ..\..\..\components\libc\compilers\common\include; ..\..\..\components\legacy; ..\libraries\nu_packages\NCT7717U; ..\..\..\components\drivers\include; ..\..\..\components\finsh; ..\libraries\nu_packages\AudioCodec; ..\..\..\components\net\sal\include; ..\..\..\components\libc\compilers\common\extension\fcntl\octal; ..\libraries\m460\rtt_port; ..\..\..\libcpu\arm\cortex-m4; ..\libraries\m460\StdDriver\inc; ..\..\..\components\dfs\dfs_v1\include; ..\..\..\components\net\sal\include\socket\sys_socket; ..\..\..\components\net\sal\include\dfs_net; ..\..\..\components\drivers\smp_call; board\NuPinConfig; ..\..\..\components\libc\compilers\common\extension; ..\..\..\components\legacy\usb\usbdevice; ..\..\..\components\net\netdev\include; ..\..\..\components\net\sal\impl; ..\..\..\components\legacy\usb\usbhost\include; board; ..\..\..\components\utilities\utest; ..\..\..\components\dfs\dfs_v1\filesystems\elmfat; ..\..\..\components\drivers\spi\sfud\inc; ..\..\..\components\legacy\usb\usbhost; ..\..\..\components\legacy\usb\usbhost\class; ..\..\..\components\legacy\usb\usbhost\core; ..\..\..\components\libc\posix\io\poll; ..\libraries\nu_packages\TPC; ..\..\..\components\dfs\dfs_v1\filesystems\devfs; ..\..\..\components\libc\posix\ipc; applications; ..\libraries\nu_packages\NuUtils\inc; ..\libraries\m460\USBHostLib\inc; ..\..\..\components\net\sal\include\socket; .; ..\..\..\components\legacy\dfs; ..\..\..\components\drivers\audio; ..\..\..\components\drivers\spi; ..\..\..\components\libc\posix\io\eventfd; ..\libraries\m460\rtt_port\emac; ..\libraries\m460\Device\Nuvoton\m460\Include; ..\..\..\components\fal\inc; ..\..\..\components\legacy\include; ..\..\..\libcpu\arm\common; ..\..\..\components\net\lwip\lwip-2.1.2\src\include\netif; ..\..\..\components\drivers\hwcrypto
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: rtthread.bin
  ILINK.IlinkOutputFile: Template.out
  ILINK.IlinkIcfFile: linking_scripts\m460_flash.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group Applications
    applications/: main.c mnt.c
  group Compiler
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
  group DeviceDrivers
    ../../../components/drivers/audio/: dev_audio.c dev_audio_pipe.c
    ../../../components/drivers/can/: dev_can.c
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/hwcrypto/: hw_crc.c hw_hash.c hw_rng.c hw_symmetric.c hwcrypto.c
    ../../../components/drivers/hwtimer/: hwtimer.c
    ../../../components/drivers/i2c/: dev_i2c_bit_ops.c dev_i2c_core.c dev_i2c_dev.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/misc/: rt_drv_pwm.c rt_inputcapture.c
    ../../../components/drivers/pin/: dev_pin.c
    ../../../components/drivers/rtc/: dev_rtc.c
    ../../../components/drivers/sdio/: dev_block.c dev_mmc.c dev_mmcsd_core.c dev_sd.c dev_sdio.c
    ../../../components/drivers/sensor/v2/: sensor.c sensor_cmd.c
    ../../../components/drivers/serial/: dev_serial.c
    ../../../components/drivers/spi/: dev_qspi_core.c dev_spi.c dev_spi_core.c dev_spi_flash_sfud.c
    ../../../components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    ../../../components/drivers/watchdog/: dev_watchdog.c
  group Drivers
    ../libraries/m460/Device/Nuvoton/m460/Source/IAR/: startup_M460.s
    ../libraries/m460/Device/Nuvoton/m460/Source/: system_m460.c
    ../libraries/m460/rtt_port/: drv_bpwm.c drv_bpwm_capture.c drv_canfd.c drv_ccap.c drv_common.c drv_crc.c drv_crypto.c drv_dac.c drv_eadc.c drv_ebi.c drv_ecap.c drv_epwm.c drv_epwm_capture.c drv_eqei.c drv_fmc.c drv_gpio.c drv_hsotg.c drv_hsusbd.c drv_i2c.c drv_i2s.c drv_pdma.c drv_qspi.c drv_rtc.c drv_scuart.c drv_sdh.c drv_sdio.c drv_softi2c.c drv_spi.c drv_spii2s.c drv_timer.c drv_tpwm.c drv_trng.c drv_uart.c drv_ui2c.c drv_usbd.c drv_usbhost.c drv_uspi.c drv_uuart.c drv_wdt.c
    board/NuPinConfig/: nutool_pincfg.c
    board/: board_dev.c nutool_modclkcfg.c
    ../libraries/m460/rtt_port/emac/: drv_emac.c mii.c synopGMAC_Dev.c synopGMAC_network_interface.c synopGMAC_plat.c
  group Fal
    ../../../components/fal/src/: fal.c fal_rtt.c fal_partition.c fal_flash.c
    ../../../components/fal/samples/porting/: fal_flash_sfud_port.c
  group Filesystem
    ../../../components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    ../../../components/dfs/dfs_v1/filesystems/elmfat/: dfs_elm.c ff.c ffunicode.c
    ../../../components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    ../../../components/finsh/: msh_file.c msh_parse.c msh.c cmd.c shell.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c signal.c thread.c timer.c
  group klibc
    ../../../src/klibc/: rt_vsscanf.c kerrno.c kstring.c kstdio.c rt_vsnprintf_tiny.c
  group Legacy
    ../../../components/legacy/ipc/: workqueue_legacy.c
  group libcpu
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m4/: context_iar.S cpuport.c
  group Libraries
    ../libraries/m460/StdDriver/src/: nu_sdh.c nu_ebi.c nu_gpio.c nu_keystore.c nu_crypto.c nu_timer.c nu_scuart.c nu_usbd.c nu_clk.c nu_wwdt.c nu_usci_i2c.c nu_rng.c nu_eadc.c nu_usci_spi.c nu_i2s.c nu_usci_uart.c nu_sys.c nu_kpi.c nu_ecap.c nu_trng.c nu_hbi.c nu_hsusbd.c nu_bmc.c nu_i2c.c nu_spi.c nu_rtc.c nu_ccap.c nu_crc.c nu_pdma.c nu_eqei.c nu_uart.c nu_canfd.c nu_dac.c nu_bpwm.c nu_spim.c nu_sc.c nu_timer_pwm.c nu_acmp.c nu_wdt.c nu_epwm.c nu_qspi.c nu_fmc.c
  group lwIP
    ../../../components/net/lwip/lwip-2.1.2/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../components/net/lwip/lwip-2.1.2/src/apps/ping/: ping.c
    ../../../components/net/lwip/lwip-2.1.2/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../components/net/lwip/lwip-2.1.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../components/net/lwip/lwip-2.1.2/src/netif/: ethernet.c lowpan6.c
    ../../../components/net/lwip/port/: ethernetif.c sys_arch.c
  group m460_usbhostlib
    ../libraries/m460/USBHostLib/src/: mem_alloc.c ehci_iso.c usb_core.c ehci.c ohci.c
  group nu_pkgs_nau8822
    ../libraries/nu_packages/AudioCodec/: acodec_nau8822.c audio_test.c
  group nu_pkgs_nct7717u
    ../libraries/nu_packages/NCT7717U/: sensor_nct7717u.c
  group POSIX
    ../../../components/libc/posix/io/poll/: poll.c select.c
  group rt_usbd
    ../../../components/legacy/usb/usbdevice/core/: usbdevice_core.c usbdevice.c
    ../../../components/legacy/usb/usbdevice/class/: mstorage.c
  group rt_usbh
    ../../../components/legacy/usb/usbhost/core/: usbhost_core.c driver.c usbhost.c hub.c
    ../../../components/legacy/usb/usbhost/class/: mass.c udisk.c
  group SAL
    ../../../components/net/netdev/src/: netdev.c netdev_ipaddr.c
    ../../../components/net/sal/dfs_net/: dfs_net.c
    ../../../components/net/sal/impl/: af_inet_lwip.c
    ../../../components/net/sal/socket/: net_netdb.c net_sockets.c
    ../../../components/net/sal/src/: sal_socket.c
  group UTest
    ../../../components/utilities/utest/: TC_uassert.c utest.c
  group Utilities
    ../../../components/utilities/ulog/backend/: console_be.c
    ../../../components/utilities/ulog/: ulog.c
