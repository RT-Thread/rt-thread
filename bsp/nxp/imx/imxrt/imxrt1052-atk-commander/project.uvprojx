# Keil uVision project project.uvprojx, settings and files
target rtthread (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: MIMXRT1052CVL5B NXP
  pack: NXP.MIMXRT1052_DFP.11.0.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x00000000,0x020000) XRAM(0x20200000,0x040000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: CPU_MIMXRT1052CVL5B, XIP_EXTERNAL_FLASH=1, SKIP_SYSCLK_INIT, RT_USING_ARMLIBC, RT_USING_LIBC, __STDC_LIMIT_MACROS, __CLK_TCK=RT_TICK_PER_SECOND, EVK_MCIMXRM, __RTTHREAD__, FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1
  c misc: --library_interface=armcc --library_type=standardlib --diag_suppress=66,1296,186
  c include: ..\..\..\..\..\components\drivers\spi\sfud\inc;..\libraries\drivers;board\MCUX_Config;..\..\..\..\..\components\drivers\spi;..\..\..\..\..\components\libc\posix\io\poll;..\..\..\..\..\components\drivers\include;.;..\..\..\..\..\libcpu\arm\cortex-m7;..\..\..\..\..\components\drivers\smp_call;..\libraries\MIMXRT1050\MIMXRT1052\drivers;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\drivers\include;..\libraries\MIMXRT1050\MIMXRT1052;..\..\..\..\..\components\dfs\dfs_v1\include;board;..\..\..\..\..\components\finsh;..\..\..\..\..\components\drivers\include;applications;..\..\..\..\..\components\libc\compilers\common\include;..\..\..\..\..\include;..\..\..\..\..\components\libc\posix\io\eventfd;..\..\..\..\..\components\dfs\dfs_v1\filesystems\devfs;..\..\..\..\..\libcpu\arm\common;..\..\..\..\..\components\libc\posix\io\epoll;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\libc\compilers\common\extension;..\libraries\MIMXRT1050\CMSIS\Include;..\..\..\..\..\components\libc\posix\ipc;board\ports;..\..\..\..\..\components\drivers\phy;..\..\..\..\..\components\libc\compilers\common\extension\fcntl\octal
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c mnt.c
  group Compiler
    ../../../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../../../components/drivers/core/: device.c
    ../../../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../../components/drivers/pin/: dev_pin.c
    ../../../../../components/drivers/serial/: dev_serial.c
    ../../../../../components/drivers/spi/: dev_spi.c dev_spi_core.c dev_spi_flash_sfud.c
    ../../../../../components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
  group Drivers
    board/MCUX_Config/: clock_config.c pin_mux.c
    board/: board.c
    ../libraries/drivers/: drv_common.c drv_gpio.c drv_spi.c drv_uart.c
  group Filesystem
    ../../../../../components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    ../../../../../components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    ../../../../../components/finsh/: msh_file.c cmd.c msh.c msh_parse.c shell.c
  group Kernel
    ../../../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    ../../../../../src/klibc/: kstdio.c kerrno.c rt_vsnprintf_tiny.c kstring.c rt_vsscanf.c
  group libcpu
    ../../../../../libcpu/arm/common/: div0.c showmem.c
    ../../../../../libcpu/arm/cortex-m7/: context_rvds.S cpu_cache.c cpuport.c
  group Libraries
    ../libraries/MIMXRT1050/MIMXRT1052/drivers/: fsl_cache.c fsl_gpio.c fsl_lpuart.c fsl_lpspi_edma.c fsl_dmamux.c fsl_clock.c fsl_xbara.c fsl_lpspi.c fsl_os_abstraction_rtthread.c fsl_common.c generic_list.c fsl_edma.c fsl_xbarb.c fsl_lpuart_edma.c
    ../libraries/MIMXRT1050/MIMXRT1052/arm/: startup_MIMXRT1052.s
    ../libraries/MIMXRT1050/MIMXRT1052/: system_MIMXRT1052.c
