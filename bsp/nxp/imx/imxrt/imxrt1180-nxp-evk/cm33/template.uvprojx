# Keil uVision project template.uvprojx, settings and files
target rtthread_ram (6220000::V6.22::ARMCLANG)
  device: MIMXRT1189CVM8C:cm33 NXP
  pack: NXP.MIMXRT1189_DFP.25.06.00
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP ELITTLE
  output: rtthread +hex
  c flags: Optim=6 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c misc: -fno-common  -fdata-sections  -fno-builtin  -mthumb
  asm misc: -x assembler-with-cpp
  library: MicroLIB
  memory RVCT1: ROM 0x8000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: .\board\linker_scripts\MIMXRT1189xxxxx_cm33_ram.scf
target rtthread_ram_industry (6220000::V6.22::ARMCLANG)
  device: MIMXRT1189CVM8C:cm33 NXP
  pack: NXP.MIMXRT1189_DFP.25.06.00
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP ELITTLE
  output: rtthread +hex
  c flags: Optim=6 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c misc: -fno-common  -fdata-sections  -fno-builtin  -mthumb
  asm misc: -x assembler-with-cpp
  library: MicroLIB
  memory RVCT1: ROM 0x8000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: .\board\linker_scripts\MIMXRT1189xxxxx_cm33_ram_industry.scf
target rtthread_flexspi_nor (6220000::V6.22::ARMCLANG)
  device: MIMXRT1189CVM8C:cm33 NXP
  pack: NXP.MIMXRT1189_DFP.25.06.00
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP ELITTLE
  output: rtthread +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c misc: -fno-common  -fdata-sections  -fno-builtin  -mthumb
  asm misc: -x assembler-with-cpp
  library: MicroLIB
  memory RVCT1: ROM 0x8000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: .\board\linker_scripts\MIMXRT1189xxxxx_cm33_flexspi_nor.scf
target rtthread_flexspi_nor_hyperram (6220000::V6.22::ARMCLANG)
  device: MIMXRT1189CVM8C:cm33 NXP
  pack: NXP.MIMXRT1189_DFP.25.06.00
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP ELITTLE
  output: rtthread +hex
  c flags: Optim=6 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c misc: -fno-common  -fdata-sections  -fno-builtin  -mthumb
  asm misc: -x assembler-with-cpp
  library: MicroLIB
  memory RVCT1: ROM 0x8000000 size 0x1000000
  memory RVCT6: RAM 0x0 size 0x20000
  memory RVCT7: RAM 0x20240000 size 0x80000
  memory RVCT8: RAM 0x202c0000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: .\board\linker_scripts\MIMXRT1189xxxxx_cm33_flexspi_nor_hyperram.scf
