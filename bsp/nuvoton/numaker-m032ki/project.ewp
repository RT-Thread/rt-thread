# IAR project project.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M031AE series Nuvoton M031AE series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: ARM_MATH_CM0; CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; _DLIB_FILE_DESCRIPTOR; __RTTHREAD__; __RT_IPC_SOURCE__; __RT_KERNEL_SOURCE__
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: applications; ..\..\..\components\drivers\phy; ..\..\..\components\libc\posix\io\poll; ..\..\..\components\drivers\include; ..\..\..\components\utilities\utest; .; ..\..\..\components\finsh; ..\..\..\components\libc\compilers\common\include; ..\..\..\include; ..\..\..\components\libc\posix\io\epoll; ..\..\..\examples\utest\testcases\smp_call; ..\..\..\components\legacy\usb\usbdevice; ..\..\..\components\libc\compilers\common\extension\fcntl\octal; board\NuPinConfig; ..\..\..\examples\utest\testcases\mm; ..\..\..\components\dfs\dfs_v1\include; ..\libraries\m031\rtt_port; ..\..\..\components\libc\compilers\common\extension; ..\..\..\components\libc\posix\ipc; ..\..\..\components\dfs\dfs_v1\filesystems\devfs; ..\..\..\examples\utest\testcases\kernel; ..\..\..\libcpu\arm\cortex-m0; ..\libraries\nu_packages\Demo; ..\libraries\nu_packages\NuUtils\inc; ..\..\..\examples\utest\testcases\tmpfs; ..\..\..\components\drivers\smp_call; board\NuClockConfig; ..\libraries\m031\StdDriver\inc; ..\libraries\m031\Device\Nuvoton\M031\Include; ..\..\..\examples\utest\testcases\lwp; board; ..\libraries\m031\CMSIS\Include; ..\..\..\libcpu\arm\common; ..\..\..\examples\utest\testcases\kernel\smp; ..\libraries\nu_packages\TPC; ..\..\..\examples\utest\testcases\utest; ..\..\..\components\libc\posix\io\eventfd; ..\..\..\examples\utest\testcases\drivers\ipc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: rtthread.bin
  ILINK.IlinkOutputFile: Template.out
  ILINK.IlinkIcfFile: linking_scripts\m031_flash.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group Applications
    applications/: mnt.c main.c
  group board
    board/NuPinConfig/: nutool_pincfg.c
    board/NuClockConfig/: nutool_modclkcfg.c
    board/: board_dev.c
  group Compiler
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/clock_time/: clock_timer.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/misc/: adc.c rt_drv_pwm.c
    ../../../components/drivers/pin/: dev_pin.c
    ../../../components/drivers/pm/: lptimer.c pm.c
    ../../../components/drivers/rtc/: dev_rtc.c
    ../../../components/drivers/serial/: dev_serial.c
    ../../../components/drivers/watchdog/: dev_watchdog.c
  group Drivers
    ../libraries/m031/Device/Nuvoton/M031/Source/IAR/: startup_M031Series.s
    ../libraries/m031/Device/Nuvoton/M031/Source/: system_M031Series.c
    ../libraries/m031/rtt_port/: drv_adc.c drv_bpwm.c drv_bpwm_capture.c drv_clk.c drv_common.c drv_crc.c drv_crypto.c drv_ebi.c drv_fmc.c drv_gpio.c drv_i2c.c drv_pdma.c drv_pwm.c drv_pwm_capture.c drv_qspi.c drv_rtc.c drv_softi2c.c drv_spi.c drv_spii2s.c drv_timer.c drv_timer_capture.c drv_uart.c drv_ui2c.c drv_usbd.c drv_uspi.c drv_uuart.c drv_wdt.c
  group Filesystem
    ../../../components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    ../../../components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    ../../../components/finsh/: cmd.c msh.c msh_parse.c shell.c msh_file.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    ../../../src/klibc/: kstring.c rt_vsnprintf_tiny.c kstdio.c rt_vsscanf.c kerrno.c
  group libcpu
    ../../../libcpu/arm/common/: div0.c showmem.c
    ../../../libcpu/arm/cortex-m0/: context_iar.S cpuport.c
  group Libraries
    ../libraries/m031/StdDriver/src/: nu_usci_uart.c nu_acmp.c nu_wwdt.c nu_usci_spi.c nu_pdma.c nu_usbd.c nu_spi.c nu_pwm.c nu_ebi.c nu_qspi.c nu_fmc.c nu_clk.c nu_timer.c nu_usci_i2c.c nu_gpio.c nu_adc.c nu_uart.c nu_i2c.c nu_bpwm.c nu_crc.c nu_rtc.c nu_wdt.c nu_sys.c
  group nu_pkgs_demo
    ../libraries/nu_packages/Demo/: smp_demo.c ccap_saver.c atdev_utils.c hwsem_counter.c slcd_show_tick.c usbd_cdc_vcom_echo.c ccap_demo.c usbd_hid_dance_mouse.c wormhole_demo.c
  group rt_usbd
    ../../../components/legacy/usb/usbdevice/class/: hid.c
    ../../../components/legacy/usb/usbdevice/core/: usbdevice.c usbdevice_core.c
  group UTest
    ../../../components/utilities/utest/: TC_uassert.c utest.c
  group utestcases
    ../../../examples/utest/testcases/kernel/: mem_tc.c
    ../../../examples/utest/testcases/utest/: pass_tc.c
