# IAR project project.ewp, settings and files
configuration rtthread (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1052xxx5B NXP MIMXRT1052xxx5B
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; CPU_MIMXRT1052CVL5B; SKIP_SYSCLK_INIT; EVK_MCIMXRM; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; XIP_EXTERNAL_FLASH=1; __RTTHREAD__; __RT_IPC_SOURCE__; __RT_KERNEL_SOURCE__
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ..\..\..\..\..\include; ..\..\..\..\..\components\libc\posix\io\epoll; ..\libraries\MIMXRT1050\MIMXRT1052\drivers; board\MCUX_Config; board; ..\..\..\..\..\components\libc\posix\io\poll; ..\libraries\MIMXRT1050\MIMXRT1052; board\ports; ..\..\..\..\..\libcpu\arm\common; ..\..\..\..\..\libcpu\arm\cortex-m7; ..\libraries\MIMXRT1050\CMSIS\Include; ..\..\..\..\..\components\finsh; ..\..\..\..\..\components\libc\posix\ipc; ..\..\..\..\..\components\drivers\include; ..\libraries\drivers; ..\..\..\..\..\components\libc\posix\io\eventfd; ..\..\..\..\..\components\drivers\smp_call; .; applications; ..\..\..\..\..\components\libc\compilers\common\extension; ..\..\..\..\..\components\libc\compilers\common\include; ..\..\..\..\..\components\drivers\phy; ..\..\..\..\..\components\libc\compilers\common\extension\fcntl\octal
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: template.srec
  ILINK.IlinkOutputFile: rtthread.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Applications
    applications/: main.c
  group Compiler
    ../../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../../../components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
  group DeviceDrivers
    ../../../../../components/drivers/core/: device.c
    ../../../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../../components/drivers/pin/: dev_pin.c
    ../../../../../components/drivers/serial/: dev_serial.c
  group Drivers
    board/MCUX_Config/: clock_config.c pin_mux.c
    board/: board.c
    ../libraries/drivers/: drv_common.c drv_gpio.c drv_uart.c
  group Finsh
    ../../../../../components/finsh/: shell.c cmd.c msh_parse.c msh.c
  group Kernel
    ../../../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    ../../../../../src/klibc/: kstring.c kstdio.c rt_vsnprintf_tiny.c rt_vsscanf.c kerrno.c
  group libcpu
    ../../../../../libcpu/arm/common/: div0.c showmem.c
    ../../../../../libcpu/arm/cortex-m7/: context_iar.S cpu_cache.c cpuport.c
  group Libraries
    ../libraries/MIMXRT1050/MIMXRT1052/drivers/: fsl_common.c fsl_gpio.c fsl_clock.c fsl_cache.c generic_list.c fsl_lpuart.c fsl_xbara.c fsl_os_abstraction_rtthread.c fsl_xbarb.c
    ../libraries/MIMXRT1050/MIMXRT1052/iar/: startup_MIMXRT1052.s
    ../libraries/MIMXRT1050/MIMXRT1052/: system_MIMXRT1052.c
