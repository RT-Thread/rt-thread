# Keil uVision project project.uvprojx, settings and files
target GD32E230C_EVAL (6120000::V6.12::.\ARMCLANG)
  device: GD32E230C8 GigaDevice
  pack: GigaDevice.GD32E23x_DFP.1.0.0
  cpu: IRAM(0x20000000,0x0002000) IROM(0x08000000,0x0010000) CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: GD32E230C_EVAL
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RT_USING_ARMLIBC, RT_USING_LIBC, USE_STDPERIPH_DRIVER, GD32E23X, GD32E23X_HD, __CLK_TCK=RT_TICK_PER_SECOND, __RTTHREAD__, __STDC_LIMIT_MACROS
  c include: ..\..\..\..\components\drivers\include;..\libraries\gd32_drivers\config;..\..\..\..\components\libc\compilers\common\include;..\..\..\..\components\libc\compilers\common\extension;..\..\..\..\libcpu\arm\cortex-m23;..\..\..\..\components\drivers\smp_call;packages\gd32-arm-cmsis-latest\GD32E23x\GD\GD32E23x\Include;..\..\..\..\components\net\utest;..\..\..\..\components\drivers\include;..\..\..\..\components\drivers\include;..\libraries\gd32_drivers;packages\gd32-arm-cmsis-latest\GD32E23x;applications;board;..\..\..\..\include;.;..\..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\..\libcpu\arm\common;..\..\..\..\components\libc\posix\io\poll;..\..\..\..\components\libc\posix\io\epoll;..\..\..\..\components\libc\posix\ipc;..\..\..\..\components\drivers\include;..\..\..\..\components\drivers\include;..\..\..\..\components\libc\posix\io\eventfd;..\..\..\..\components\drivers\phy;packages\gd32-arm-series-latest\GD32E23x\GD32E23x_standard_peripheral\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Applications
    applications/: main.c
  group Compiler
    ../../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../../components/drivers/core/: device.c
    ../../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../components/drivers/pin/: dev_pin.c
    ../../../../components/drivers/serial/: dev_serial.c
  group Drivers
    board/: board.c
    ../libraries/gd32_drivers/: drv_gpio.c drv_usart.c
  group Kernel
    ../../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    ../../../../src/klibc/: rt_vsscanf.c rt_vsnprintf_tiny.c kerrno.c kstdio.c kstring.c
  group libcpu
    ../../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../../libcpu/arm/cortex-m23/: context_rvds.S cpuport.c
  group Libraries
    packages/gd32-arm-cmsis-latest/GD32E23x/GD/GD32E23x/Source/ARM/: startup_gd32e23x.s
    packages/gd32-arm-cmsis-latest/GD32E23x/GD/GD32E23x/Source/: system_gd32e23x.c
    packages/gd32-arm-series-latest/GD32E23x/GD32E23x_standard_peripheral/Source/: gd32e23x_dma.c gd32e23x_exti.c gd32e23x_gpio.c gd32e23x_misc.c gd32e23x_rcu.c gd32e23x_syscfg.c gd32e23x_usart.c
software components: CMSIS:CORE 5.0.2
