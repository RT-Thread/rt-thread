# Keil uVision project project.uvproj, settings and files
target rtthread (ARM-ADS)
  device: AT91SAM9260 Atmel
  cpu: IRAM(0x200000-0x200FFF) IRAM2(0x300000-0x300FFF) IROM(0x100000-0x107FFF) CLOCK(18432000) CPUTYPE(ARM926EJ-S)
  output: rtthread
  c flags: Optim=1 wLevel=2
  c define: RT_USING_ARM_LIBC, __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND
  c include: applications;.;..\..\libcpu\arm\common;..\..\libcpu\arm\arm926;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\drivers\include;drivers;..\..\components\dfs\include;..\..\components\dfs\filesystems\devfs;..\..\components\finsh;.;..\..\include;..\..\components\libc\compilers\armlibc;..\..\components\libc\compilers\common;..\..\components\libc\compilers\common\nogcc;platform;..\..\examples\utest\testcases\kernel
  asm include: .\platform
  memory RVCT1: ROM 0x20000000 size 0x800000
  memory RVCT4: ROM 0x100000 size 0x8000
  memory RVCT6: RAM 0x20800000 size 0x1800000
  memory RVCT9: RAM 0x200000 size 0x1000
  memory RVCT10: RAM 0x300000 size 0x1000
  scatter file: .\link_scripts\at91sam9260_ram.scat
  group Applications
    applications/: application.c
  group CPU
    ../../libcpu/arm/common/: div0.c showmem.c backtrace.c
    ../../libcpu/arm/arm926/: trap.c cpuport.c mmu.c stack.c machine.c start_rvds.S context_rvds.S
  group DeviceDrivers
    ../../components/drivers/misc/: pin.c
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/src/: dataqueue.c ringblk_buf.c pipe.c ringbuffer.c workqueue.c waitqueue.c completion.c
  group Drivers
    drivers/: usart.c board.c led.c
  group Filesystem
    ../../components/dfs/src/: dfs_posix.c dfs_poll.c dfs_file.c dfs.c dfs_fs.c dfs_select.c
    ../../components/dfs/filesystems/devfs/: devfs.c
  group Finsh
    ../../components/finsh/: shell.c msh.c msh_file.c cmd.c
  group Kernel
    ../../src/: object.c clock.c kservice.c timer.c device.c components.c mem.c thread.c idle.c mempool.c irq.c scheduler.c ipc.c
  group libc
    ../../components/libc/compilers/armlibc/: libc.c mem_std.c syscalls.c stdio.c
    ../../components/libc/compilers/common/: time.c unistd.c stdlib.c delay.c
  group Platform
    platform/: reset.c interrupt.c system_clock.c rt_low_level_init.c
