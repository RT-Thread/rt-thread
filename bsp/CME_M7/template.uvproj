# Keil uVision project template.uvproj, settings and files
target rtthread (ARM-ADS)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.4.1.0
  cpu: CPUTYPE("Cortex-M3") CLOCK(10000000) ESEL ELITTLE
  output: rtthread +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  scatter file: CME_M7.sct
