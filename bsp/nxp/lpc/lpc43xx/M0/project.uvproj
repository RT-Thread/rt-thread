# Keil uVision project project.uvproj, settings and files
target LPC43xx SPIFI (ARM-ADS)
  device: LPC4357 CM0 NXP
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: rtthread_lpc43xx
  AfterMake: fromelf --bin !L --output rtthread.bin
  AfterMake: C:\Python27\python.exe ..\bin2C.py rtthread.bin ..\M4\applications\M0_CODE.h
  c flags: Optim=1 OneElfS=1
  c define: __RTTHREAD__, USE_SPIFI, RT_USING_ARMLIBC, CORE_M0, __STDC_LIMIT_MACROS, RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND
  c include: ..\..\..\..\..\components\libc\posix\ipc;..\..\..\..\..\components\libc\posix\io\eventfd;..\..\..\..\..\components\drivers\include;applications;..\..\..\..\..\components\drivers\phy;..\..\..\..\..\components\libc\posix\io\epoll;..\libraries\Device\NXP\LPC43xx\Include;..\..\..\..\..\components\drivers\smp_call;..\..\..\..\..\components\finsh;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\..\..\components\libc\compilers\common\include;.;..\drivers;..\..\..\..\..\libcpu\arm\cortex-m0;..\..\..\..\..\libcpu\arm\common;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\net\utest;..\..\..\..\..\components\libc\posix\io\poll;..\..\..\..\..\components\libc\compilers\common\extension;..\..\..\..\..\include;..\libraries\CMSIS\Include
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT1: ROM 0x14000000 size 0x400000
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: .\rtthread_lpc43xx.sct
  group Applications
    applications/: application.c board.c startup.c
  group CMSIS
    ../libraries/Device/NXP/LPC43xx/Source/Templates/: system_LPC43xx.c
    ../libraries/Device/NXP/LPC43xx/Source/Templates/ARM/: startup_LPC43xx_M0.s
  group CPU
    ../../../../../libcpu/arm/common/: div0.c showmem.c
    ../../../../../libcpu/arm/cortex-m0/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../../../../components/drivers/core/: device.c
    ../../../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../../components/drivers/serial/: dev_serial.c
  group Drivers
    ../drivers/: drv_led.c drv_uart.c
  group Finsh
    ../../../../../components/finsh/: shell.c msh.c msh_parse.c
  group Kernel
    ../../../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group Libc
    ../../../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../../../src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
