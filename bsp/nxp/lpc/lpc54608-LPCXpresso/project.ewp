# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC54608J512 NXP LPC54608J512
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: SDK_DEBUGCONSOLE=0; CORE_M4; CPU_LPC54608; CPU_LPC54608J512ET180=1; _TIMESPEC_DEFINED; RT_USING_DLIBC; _DLIB_FILE_DESCRIPTOR; _DLIB_THREAD_SUPPORT
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: SDK_2.2_LPCXpresso54608/devices/LPC54608; SDK_2.2_LPCXpresso54608/CMSIS/Include; ../../components/libc/compilers/dlib; SDK_2.2_LPCXpresso54608/sdmmc_2.1.2/src; ../../components/cplusplus; ../../components/drivers/include; ../../components/libc/time; ../../libcpu/arm/cortex-m4; ../../components/finsh; ../../components/net/lwip-2.0.2/src; SDK_2.2_LPCXpresso54608/sdmmc_2.1.2/inc; drivers; ../../libcpu/arm/common; .; SDK_2.2_LPCXpresso54608/devices/LPC54608/utilities; ../../components/libc/pthreads; ../../components/net/lwip-2.0.2/src/arch/include; ../../components/drivers/spi; ../../components/net/lwip-2.0.2/src/include; ../../components/dfs/filesystems/elmfat; ../../components/net/lwip-2.0.2/src/include/posix; applications; ../../include; SDK_2.2_LPCXpresso54608/devices/LPC54608/drivers; ../../components/net/lwip-2.0.2/src/include/netif; ../../components/dfs/include; ../../components/net/lwip-2.0.2/src/include/ipv4
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: LPC54608J512_flash.icf
  ILINK.IlinkAdditionalLibs: SDK_2.2_LPCXpresso54608/devices/LPC54608/iar/iar_lib_power.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; SDK_DEBUGCONSOLE=0; CORE_M4; CPU_LPC54608; CPU_LPC54608J512ET180=1; _TIMESPEC_DEFINED; RT_USING_DLIBC; _DLIB_FILE_DESCRIPTOR; _DLIB_THREAD_SUPPORT
  ICCARM.CCOptLevel: 3
  group Libraries
    SDK_2.2_LPCXpresso54608/sdmmc_2.1.2/src/: fsl_sd.c fsl_sdmmc.c fsl_host.c fsl_sd_event.c
    SDK_2.2_LPCXpresso54608/devices/LPC54608/drivers/: fsl_adc.c fsl_clock.c fsl_common.c fsl_crc.c fsl_ctimer.c fsl_dma.c fsl_dmic.c fsl_dmic_dma.c fsl_eeprom.c fsl_emc.c fsl_enet.c fsl_flashiap.c fsl_flexcomm.c fsl_fmc.c fsl_fmeas.c fsl_gint.c fsl_gpio.c fsl_i2c.c fsl_i2c_dma.c fsl_i2s.c fsl_i2s_dma.c fsl_inputmux.c fsl_lcdc.c fsl_mcan.c fsl_mrt.c fsl_pint.c fsl_power.c fsl_reset.c fsl_rit.c fsl_rtc.c fsl_sctimer.c fsl_sdif.c fsl_spi.c fsl_spi_dma.c fsl_spifi.c fsl_spifi_dma.c fsl_usart.c fsl_usart_dma.c fsl_utick.c fsl_wwdt.c
  group CMSIS
    SDK_2.2_LPCXpresso54608/devices/LPC54608/iar/: startup_LPC54608.s
    SDK_2.2_LPCXpresso54608/devices/LPC54608/: system_LPC54608.c
  group Drivers
    drivers/: board.c clock_config.c drt_mpu.c drv_emac.c drv_ft5406.c drv_i2c.c drv_lcd.c drv_sd.c drv_sdram.c drv_sram.c drv_uart.c fsl_phy.c
  group Applications
    applications/: application.c mnt.c startup.c
  group Kernel
    ../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group CORTEX-M4
    ../../libcpu/arm/cortex-m4/: cpuport.c context_iar.S
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
  group CPlusPlus
    ../../components/cplusplus/: cxx_Mutex.cpp cxx_Semaphore.cpp cxx_Thread.cpp cxx_crt.cpp crt_init.c
  group DeviceDrivers
    ../../components/drivers/misc/: pin.c
    ../../components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    ../../components/drivers/sdio/: block_dev.c mmcsd_core.c sd.c sdio.c mmc.c
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/rtc/: rtc.c
    ../../components/drivers/mtd/: mtd_nand.c
    ../../components/drivers/spi/: spi_core.c spi_dev.c enc28j60.c
    ../../components/drivers/src/: completion.c dataqueue.c pipe.c ringbuffer.c waitqueue.c workqueue.c
  group pthreads
    ../../components/libc/pthreads/: mqueue.c pthread.c pthread_attr.c pthread_barrier.c pthread_cond.c pthread_mutex.c pthread_rwlock.c pthread_spin.c pthread_tls.c sched.c semaphore.c
    ../../components/libc/time/: clock_time.c posix_sleep.c
  group dlib
    ../../components/libc/compilers/dlib/: environ.c libc.c rmtx.c stdio.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c
  group finsh
    ../../components/finsh/: shell.c symbol.c cmd.c msh.c msh_cmd.c msh_file.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_var.c finsh_vm.c finsh_token.c
  group lwIP
    ../../components/net/lwip-2.0.2/src/arch/: sys_arch.c
    ../../components/net/lwip-2.0.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../components/net/lwip-2.0.2/src/core/: def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../components/net/lwip-2.0.2/src/netif/: ethernet.c ethernetif.c lowpan6.c
    ../../components/net/lwip-2.0.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group Filesystem
    ../../components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
    ../../components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
