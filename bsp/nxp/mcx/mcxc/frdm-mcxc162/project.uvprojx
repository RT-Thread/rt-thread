# Keil uVision project project.uvprojx, settings and files
target rtthread-frdm-mcxc162 (6230000::V6.23::ARMCLANG)
  device: MCXC162VFT NXP
  pack: NXP.MCXC162_DFP.26.06.00
  cpu: IRAM(0x20000000,0x00003000) IROM(0x00000000,0x00010000) CPUTYPE("Cortex-M23") CLOCK(72000000) ELITTLE
  output: rtthread
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=3
  c define: __RTTHREAD__, CPU_MCXC162VFT, __CLK_TCK=RT_TICK_PER_SECOND, __STDC_LIMIT_MACROS, RT_USING_ARMLIBC, RT_USING_LIBC
  c misc: --target=arm-arm-none-eabi -mcpu=cortex-m23 -mfloat-abi=soft
  c include: ..\..\..\..\..\libcpu\arm\cortex-m23;packages\nxp-mcx-series-latest\MCXC162\periph3;applications;..\..\..\..\..\components\libc\posix\ipc;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\net\utest;board;..\..\..\..\..\components\libc\posix\io\eventfd;..\..\..\..\..\libcpu\arm\common;..\..\..\..\..\components\libc\posix\io\poll;..\..\..\..\..\include;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\libc\posix\io\epoll;..\..\..\..\..\components\libc\compilers\common\include;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\finsh;.;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\drivers\smp_call;..\..\..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\..\..\components\drivers\include;packages\nxp-mcx-series-latest\MCXC162\drivers;packages\nxp-mcx-series-latest\MCXC162;board\MCUX_Config\board;packages\nxp-mcx-cmsis-latest\Core\Include;..\..\..\..\..\components\libc\compilers\common\extension;..\libraries\drivers\mcxc162
  asm misc: -x assembler-with-cpp
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x3000
  scatter file: .\packages\nxp-mcx-series-latest\MCXC162\arm\MCXC162_flash.scf
  link misc: --keep *.o(.rti_fn.*) --keep *.o(FSymTab) --keep *.o(VSymTab)
  group Applications
    applications/: main.c
  group CPU
    ../../../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../../../libcpu/arm/cortex-m23/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../../../../components/drivers/core/: device.c
    ../../../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../../components/drivers/pin/: dev_pin.c
    ../../../../../components/drivers/serial/: dev_serial.c
  group Drivers
    board/MCUX_Config/board/: clock_config.c pin_mux.c
    board/: board.c
    ../libraries/drivers/mcxc162/: drv_pin.c drv_uart.c
  group Finsh
    ../../../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group Libc
    ../../../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../../../src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
  group Libraries
    packages/nxp-mcx-series-latest/MCXC162/drivers/: fsl_clock.c fsl_common.c fsl_common_arm.c fsl_gpio.c fsl_lpuart.c fsl_reset.c fsl_spc.c
    packages/nxp-mcx-series-latest/MCXC162/: startup_MCXC162.c system_MCXC162.c
