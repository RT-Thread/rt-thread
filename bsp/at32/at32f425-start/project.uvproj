# Keil uVision project project.uvproj, settings and files
target rt-thread (ARM-ADS)
  device: -AT32F425R8T7 ArteryTek
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x08000000-0x0800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4")
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: __STDC_LIMIT_MACROS, RT_USING_ARMLIBC, USE_STDPERIPH_DRIVER, RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND, __RTTHREAD__, AT32F425C8T7
  c include: ..\..\..\include;..\libraries\rt_drivers\config;.;..\..\..\components\libc\compilers\common\include;..\..\..\components\utilities\libadt;..\..\..\components\drivers\include;..\libraries\rt_drivers;..\..\..\components\libc\compilers\common\extension;..\..\..\components\drivers\include;..\..\..\components\finsh;..\..\..\libcpu\arm\common;..\libraries\AT32F425_Firmware_Library\drivers\inc;..\..\..\components\libc\posix\io\poll;board;..\..\..\components\drivers\include;..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\components\libc\posix\ipc;board\inc;..\..\..\libcpu\arm\cortex-m4;..\..\..\components\libc\posix\io\stdio;..\libraries\AT32F425_Firmware_Library\cmsis\cm4\device_support;applications;..\libraries\AT32F425_Firmware_Library\cmsis\cm4\core_support
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdio.c cstdlib.c cstring.c ctime.c cwchar.c
  group CPU
    ../../../libcpu/arm/common/: div0.c showmem.c
    ../../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../../components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/serial/: serial.c
  group Drivers
    board/src/: at32_msp.c board.c
    ../libraries/AT32F425_Firmware_Library/cmsis/cm4/device_support/startup/mdk/: startup_at32f425.s
    ../libraries/rt_drivers/: drv_common.c drv_gpio.c drv_usart.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c thread.c timer.c
  group Libraries
    ../libraries/AT32F425_Firmware_Library/drivers/src/: at32f425_ertc.c at32f425_wwdt.c at32f425_crm.c at32f425_acc.c at32f425_wdt.c at32f425_exint.c at32f425_tmr.c at32f425_pwc.c at32f425_usb.c at32f425_debug.c at32f425_gpio.c at32f425_flash.c at32f425_crc.c at32f425_usart.c at32f425_scfg.c at32f425_misc.c at32f425_adc.c at32f425_can.c at32f425_i2c.c at32f425_spi.c at32f425_dma.c
    ../libraries/AT32F425_Firmware_Library/cmsis/cm4/device_support/: system_at32f425.c
