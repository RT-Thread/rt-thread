# Keil uVision project project.uvprojx, settings and files
target rtthread (6150000::V6.15::ARMCLANG)
  device: MIMXRT1176DVMAA:cm7 NXP
  pack: NXP.MIMXRT1176_DFP.13.1.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x20000000,0x040000) IROM(0x00200000,0x040000) XRAM(0x1ffe0000,0x020000) XRAM2(0x00000000,0x040000) XRAM3(0x20240000,0x080000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rtthread
  c flags: Optim=5 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: __STDC_LIMIT_MACROS, XIP_BOOT_HEADER_DCD_ENABLE=1, __CLK_TCK=RT_TICK_PER_SECOND, RT_USING_LIBC, CPU_MIMXRT1176DVMAA_cm7, FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1, RT_USING_ARMLIBC, ENDIANNESS, XIP_EXTERNAL_FLASH=1, __RTTHREAD__, USE_RTOS, ARM_MATH_CM7, USE_SDRAM, XIP_BOOT_HEADER_ENABLE=1
  c misc: -xc -std=gnu99 -mimplicit-float
  c include: ..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\drivers\phy;..\libraries\drivers;..\..\..\..\..\components\legacy\usb\usbhost\include;..\..\..\..\..\include;..\..\..\..\..\components\net\netdev\include;..\..\..\..\..\components\libc\posix\io\epoll;..\..\..\..\..\components\libc\compilers\common\extension;xip;..\..\..\..\..\components\drivers\include;..\libraries\MIMXRT1170\CMSIS\Include;..\..\..\..\..\components\libc\posix\ipc;..\..\..\..\..\components\legacy\usb\usbhost;..\..\..\..\..\components\libc\posix\io\poll;..\..\..\..\..\components\drivers\include;..\libraries\MIMXRT1170\MIMXRT1176;..\..\..\..\..\components\legacy\usb\usbhost\class;..\libraries\MIMXRT1170\MIMXRT1176\drivers\cm7;.;..\..\..\..\..\libcpu\arm\cortex-m7;..\..\..\..\..\components\drivers\smp_call;..\..\..\..\..\components\finsh;..\..\..\..\..\components\legacy\usb\usbhost\core;..\..\..\..\..\components\legacy\include;board;..\..\..\..\..\components\libc\posix\io\eventfd;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\libc\compilers\common\extension\fcntl\octal;board\MCUX_Config;board\ports;..\libraries\MIMXRT1170\MIMXRT1176\drivers;applications;..\..\..\..\..\libcpu\arm\common;..\..\..\..\..\components\libc\compilers\common\include;..\..\..\..\..\components\drivers\include
  memory RVCT4: ROM 0x200000 size 0x40000
  memory RVCT6: RAM 0x1ffe0000 size 0x20000
  memory RVCT7: RAM 0x0 size 0x40000
  memory RVCT8: RAM 0x20240000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\board\linker_scripts\link.sct
  link misc: --keep=*(.boot_hdr.ivt) --keep=*(.boot_hdr.boot_data) --keep=*(.boot_hdr.dcd_data) --keep=*(.boot_hdr.conf) --predefine="-DXIP_BOOT_HEADER_ENABLE=1"
  group Applications
    applications/: main.c mnt.c
  group Compiler
    ../../../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../../../components/drivers/core/: device.c
    ../../../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../../components/drivers/phy/: phy.c
    ../../../../../components/drivers/pin/: dev_pin.c
    ../../../../../components/drivers/serial/: dev_serial.c
  group Drivers
    board/MCUX_Config/: clock_config.c pin_mux.c
    board/: board.c dcd.c
    ../libraries/drivers/: drv_common.c drv_gpio.c drv_uart.c drv_usbh.c
    ../libraries/drivers/usb/host/: usb_host_devices.c usb_host_ehci.c usb_host_framework.c usb_host_hci.c
    ../libraries/drivers/usb/phy/: usb_phy.c
  group Finsh
    ../../../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    ../../../../../src/klibc/: kstdio.c rt_vsnprintf_tiny.c kstring.c rt_vsscanf.c kerrno.c
  group libcpu
    ../../../../../libcpu/arm/common/: div0.c showmem.c
    ../../../../../libcpu/arm/cortex-m7/: context_rvds.S cpu_cache.c cpuport.c
  group Libraries
    ../libraries/MIMXRT1170/MIMXRT1176/drivers/: fsl_lpuart.c fsl_common_arm.c fsl_gpio.c fsl_pmu.c fsl_os_abstraction_rtthread.c fsl_dcdc.c fsl_clock.c generic_list.c fsl_common.c fsl_anatop_ai.c
    ../libraries/MIMXRT1170/MIMXRT1176/drivers/cm7/: fsl_cache.c
    ../libraries/MIMXRT1170/MIMXRT1176/arm/: startup_MIMXRT1176_cm7.s
    ../libraries/MIMXRT1170/MIMXRT1176/: system_MIMXRT1176_cm7.c
  group rt_usbh
    ../../../../../components/legacy/usb/usbhost/core/: usbhost.c hub.c usbhost_core.c driver.c
  group SAL
    ../../../../../components/net/netdev/src/: netdev_ipaddr.c netdev.c
  group xip
    xip/: fsl_flexspi_nor_boot.c evkmimxrt1170_flexspi_nor_config.c
