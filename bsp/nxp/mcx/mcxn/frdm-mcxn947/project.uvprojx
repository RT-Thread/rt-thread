# Keil uVision project project.uvprojx, settings and files
target rtthread-frdm-mcxn947 (6160000::V6.16::ARMCLANG)
  device: MCXN947VDF:cm33_core0 NXP
  pack: NXP.MCXN947_DFP.17.0.0
  cpu: IRAM(0x20000000,0x060000) IRAM2(0x20060000,0x8000) IROM(0x03000000,0x040000) IROM2(0x13000000,0x040000) XRAM(0x30060000,0x8000) XRAM2(0x04000000,0x018000) XRAM3(0x14000000,0x018000) XROM(0x00000000,0x100000) XROM2(0x00100000,0x100000) XROM3(0x10000000,0x100000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: rtthread
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=3
  c define: __STDC_LIMIT_MACROS, RT_USING_ARMLIBC, __RTTHREAD__, CPU_MCXN947VDF_cm33_core0, RT_USING_LIBC, DEBUG, __CLK_TCK=RT_TICK_PER_SECOND
  c misc: --target=arm-arm-none-eabi
  c include: ..\Libraries\MCXN947\MCXN947;..\..\..\..\..\components\drivers\usb\cherryusb\class\msc;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\finsh;..\..\..\..\..\components\drivers\usb\cherryusb\class\hid;..\..\..\..\..\components\net\lwip\lwip-2.1.2\src\include\netif;..\..\..\..\..\components\drivers\usb\cherryusb\class\vendor\net;..\..\..\..\..\components\drivers\usb\cherryusb\class\midi;..\..\..\..\..\components\drivers\usb\cherryusb\class\cdc;..\..\..\..\..\components\drivers\usb\cherryusb\common;..\..\..\..\..\components\dfs\dfs_v1\filesystems\devfs;..\..\..\..\..\components\drivers\include;..\Libraries\MCXN947\MCXN947\drivers\romapi\mem_interface;..\Libraries\CMSIS\Core\Include;..\..\..\..\..\libcpu\arm\cortex-m33;..\..\..\..\..\components\libc\compilers\common\extension;board;..\Libraries\MCXN947\MCXN947\drivers\romapi\runbootloader;applications;..\..\..\..\..\components\utilities\ulog;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\libc\posix\io\epoll;..\..\..\..\..\components\drivers\usb\cherryusb\class\hub;..\..\..\..\..\components\drivers\usb\cherryusb\class\dfu;..\..\..\..\..\components\net\lwip\port;..\..\..\..\..\components\drivers\usb\cherryusb\class\audio;..\..\..\..\..\components\dfs\dfs_v1\include;..\..\..\..\..\components\libc\posix\ipc;..\..\..\..\..\components\libc\compilers\common\include;..\..\..\..\..\components\drivers\usb\cherryusb\class\vendor\serial;..\Libraries\MCXN947\MCXN947\drivers\romapi\nboot;..\..\..\..\..\components\libc\posix\io\eventfd;..\Libraries\MCXN947\MCXN947\drivers\romapi\flash;..\..\..\..\..\components\drivers\usb\cherryusb\port\chipidea;..\..\..\..\..\components\drivers\usb\cherryusb\class\wireless;..\Libraries\drivers;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\libc\compilers\common\extension\fcntl\octal;board\MCUX_Config\board;..\Libraries\MCXN947\MCXN947\drivers;..\..\..\..\..\libcpu\arm\common;..\..\..\..\..\components\libc\posix\io\poll;..\Libraries\drivers\config;..\..\..\..\..\components\net\netdev\include;..\..\..\..\..\components\drivers\usb\cherryusb\core;..\..\..\..\..\components\drivers\usb\cherryusb\class\video;..\..\..\..\..\components\net\lwip\lwip-2.1.2\src\include;..\..\..\..\..\components\net\lwip\lwip-2.1.2\src\include\compat\posix;..\..\..\..\..\include;.;..\..\..\..\..\components\dfs\dfs_v1\filesystems\elmfat
  asm misc: -x assembler-with-cpp
  memory RVCT1: ROM 0x0 size 0x100000
  memory RVCT2: ROM 0x100000 size 0x100000
  memory RVCT3: ROM 0x10000000 size 0x100000
  memory RVCT4: ROM 0x3000000 size 0x40000
  memory RVCT5: ROM 0x13000000 size 0x40000
  memory RVCT6: RAM 0x30060000 size 0x8000
  memory RVCT7: RAM 0x4000000 size 0x18000
  memory RVCT8: RAM 0x14000000 size 0x18000
  memory RVCT9: RAM 0x20000000 size 0x60000
  memory RVCT10: RAM 0x20060000 size 0x8000
  scatter file: .\board\linker_scripts\MCXN947_cm33_core0_flash.scf
  group Applications
    applications/: main.c
  group CherryUSB
    ../../../../../components/drivers/usb/cherryusb/class/msc/: usbh_msc.c
    ../../../../../components/drivers/usb/cherryusb/class/hub/: usbh_hub.c
    ../../../../../components/drivers/usb/cherryusb/platform/rtthread/: usb_check.c usbh_dfs.c usbh_lwip.c usb_msh.c
    ../../../../../components/drivers/usb/cherryusb/class/hid/: usbh_hid.c
    ../../../../../components/drivers/usb/cherryusb/class/wireless/: usbh_rndis.c
    ../../../../../components/drivers/usb/cherryusb/port/ehci/: usb_glue_mcx.c usb_hc_ehci.c
    ../../../../../components/drivers/usb/cherryusb/core/: usbh_core.c
    ../../../../../components/drivers/usb/cherryusb/osal/: usb_osal_rtthread.c
    ../../../../../components/drivers/usb/cherryusb/class/cdc/: usbh_cdc_acm.c
  group Compiler
    ../../../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../../../components/drivers/core/: device.c
    ../../../../../components/drivers/hwtimer/: hwtimer.c
    ../../../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../../components/drivers/pin/: dev_pin.c
    ../../../../../components/drivers/serial/: serial.c
  group Drivers
    board/MCUX_Config/board/: clock_config.c pin_mux.c
    board/: board.c cherryusb_port.c usb_phy.c
    ../Libraries/drivers/: drv_pin.c drv_uart.c
  group Filesystem
    ../../../../../components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    ../../../../../components/dfs/dfs_v1/filesystems/elmfat/: dfs_elm.c ff.c ffunicode.c
    ../../../../../components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    ../../../../../components/finsh/: msh_file.c msh.c cmd.c msh_parse.c shell.c
  group Kernel
    ../../../../../src/: clock.c components.c cpu_up.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
    ../../../../../src/klibc/: kstdio.c kstring.c
  group libcpu
    ../../../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../../../libcpu/arm/cortex-m33/: context_rvds.S cpuport.c syscall_rvds.S trustzone.c
  group Libraries
    ../Libraries/MCXN947/MCXN947/drivers/: fsl_smartcard_emvsim.c fsl_vbat.c fsl_gdet.c fsl_irtc.c fsl_powerquad_matrix.c fsl_lpspi.c fsl_spc.c fsl_powerquad_filter.c fsl_flexcan.c fsl_lpi2c_edma.c fsl_erm.c fsl_common.c fsl_cmc.c fsl_flexcan_edma.c fsl_intm.c fsl_common_arm.c fsl_tdet.c fsl_flexio_uart_edma.c fsl_sema42.c fsl_lpuart.c fsl_flexspi.c fsl_lpuart_edma.c fsl_powerquad_basic.c fsl_lpadc.c fsl_tsi_v6.c fsl_sai.c fsl_vref.c fsl_utick.c fsl_edma.c fsl_inputmux.c fsl_ctimer.c fsl_sctimer.c fsl_flexio_i2c_master.c fsl_smartdma_rt500.c fsl_powerquad_math.c fsl_lpi2c.c fsl_pdm.c fsl_edma_soc.c fsl_flexio_mculcd.c fsl_mrt.c fsl_wwdt.c fsl_i3c.c fsl_lpflexcomm.c fsl_gpio.c fsl_pdm_edma.c fsl_dac14.c fsl_pwm.c fsl_ewm.c fsl_plu.c fsl_cache_lpcac.c fsl_itrc.c fsl_flexio.c fsl_freqme.c fsl_ostimer.c fsl_cache.c fsl_i3c_edma.c fsl_enet.c fsl_sai_edma.c fsl_smartdma.c fsl_cdog.c fsl_usdhc.c fsl_evtg.c fsl_smartdma_mcxn.c fsl_flexspi_edma.c fsl_pint.c fsl_clock.c fsl_flexio_mculcd_smartdma.c fsl_lpcmp.c fsl_flexio_uart.c fsl_power.c fsl_syspm.c fsl_smartcard_phy_emvsim.c fsl_wuu.c fsl_trdc.c fsl_eim.c fsl_sinc.c fsl_opamp.c fsl_lpspi_edma.c fsl_powerquad_data.c fsl_flexio_spi.c fsl_lptmr.c fsl_powerquad_transform.c fsl_reset.c fsl_flexio_mculcd_edma.c fsl_dac.c fsl_puf_v3.c fsl_qdc.c fsl_crc.c fsl_flexio_spi_edma.c
    ../Libraries/MCXN947/MCXN947/: system_MCXN947_cm33_core0.c
    ../Libraries/MCXN947/MCXN947/arm/: startup_MCXN947_cm33_core0.s
    ../Libraries/MCXN947/MCXN947/drivers/romapi/nboot/src/: fsl_nboot.c
    ../Libraries/MCXN947/MCXN947/drivers/romapi/runbootloader/src/: fsl_runbootloader.c
    ../Libraries/MCXN947/MCXN947/drivers/romapi/mem_interface/src/: fsl_mem_interface.c
    ../Libraries/MCXN947/MCXN947/drivers/romapi/flash/src/: fsl_flash.c
  group lwIP
    ../../../../../components/net/lwip/lwip-2.1.2/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../../../components/net/lwip/lwip-2.1.2/src/apps/ping/: ping.c
    ../../../../../components/net/lwip/lwip-2.1.2/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../../../components/net/lwip/lwip-2.1.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../../../components/net/lwip/lwip-2.1.2/src/netif/: ethernet.c lowpan6.c
    ../../../../../components/net/lwip/port/: ethernetif.c sys_arch.c
  group SAL
    ../../../../../components/net/netdev/src/: netdev_ipaddr.c netdev.c
  group Utilities
    ../../../../../components/utilities/ulog/backend/: console_be.c
    ../../../../../components/utilities/ulog/: ulog.c
