# Keil uVision project project.uvproj, settings and files
target RT-Thread NUC100 (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: rtthread-nuc140
  c flags: Optim=3 OneElfS=1
  c include: .;..\..\include;..\..\components\finsh
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --entry Reset_Handler --keep __fsym_* --keep __vsym_*
  group Startup
    ./: board.c startup.c uart.c rtconfig.h application.c
  group NUC100
    ../../libcpu/arm/nuc1xx/: fault.c interrupt.c stack.c context_rvds.S fault_rvds.S start_rvds.S
  group CMSIS
    ./CMSIS/CM0/: system_NUC1xx.c core_cm0.c
  group Kernel
    ../../src/: timer.c clock.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c slab.c thread.c
  group finsh
    ../../components/finsh/: symbol.c cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c shell.c
