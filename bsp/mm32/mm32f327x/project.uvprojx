# Keil uVision project project.uvprojx, settings and files
target rtthread (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MM32F3277G9P MindMotion
  pack: MindMotion.MM32F3270_DFP.1.0.4
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rtthread +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND, __STDC_LIMIT_MACROS, RT_USING_ARMLIBC, __RTTHREAD__
  c include: ..\..\..\components\finsh;packages\mm32f3270x-cmsis-latest\CMSIS\Include;applications;..\..\..\components\libc\posix\io\poll;..\..\..\include;.;..\..\..\libcpu\arm\common;..\..\..\libcpu\arm\cortex-m3;packages\mm32f3270x-cmsis-latest\CMSIS\Device\MM32\MM32F3277\Include;..\libraries\HAL_Drivers;..\..\..\components\libc\posix\io\eventfd;board;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\libc\compilers\common\extension;..\libraries\HAL_Drivers\drivers;..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\components\net\utest;..\..\..\components\drivers\smp_call;..\..\..\components\libc\compilers\common\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\phy;packages\mm32f3270x-cmsis-latest\CMSIS\Device\MM32\MM32F3277\Include;..\libraries\HAL_Drivers\drivers\config;..\..\..\components\libc\posix\io\epoll;packages\mm32f3270x-cmsis-latest\CMSIS\Include;packages\mm32f3270x-hal-driver-latest\Inc;..\..\..\components\libc\posix\ipc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group CMSIS
    packages/mm32f3270x-cmsis-latest/CMSIS/Device/MM32/MM32F3277/Source/Templates/: system_mm32f3277g.c
    packages/mm32f3270x-cmsis-latest/CMSIS/Device/MM32/MM32F3277/Source/Templates/arm/: startup_mm32f3270.s
  group CPU
    ../../../libcpu/arm/common/: div0.c showmem.c
    ../../../libcpu/arm/cortex-m3/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/pin/: dev_pin.c
    ../../../components/drivers/serial/: dev_serial.c
  group Drivers
    ../libraries/HAL_Drivers/drivers/: drv_gpio.c drv_uart.c
    board/: board.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group Libc
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
  group Libraries
    packages/mm32f3270x-hal-driver-latest/Src/: hal_adc.c hal_comp.c hal_dac.c hal_dma.c hal_exti.c hal_fsmc.c hal_gpio.c hal_i2c.c hal_iwdg.c hal_rcc.c hal_rtc.c hal_sdio.c hal_spi.c hal_syscfg.c hal_tim_16b.c hal_tim_32b.c hal_tim_adv.c hal_tim_basic.c hal_uart.c hal_usb.c hal_wwdg.c
