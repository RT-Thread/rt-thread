<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\c42412a_example_flash.ewp</path>
	</project>
</workspace>
