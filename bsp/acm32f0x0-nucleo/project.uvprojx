# Keil uVision project project.uvprojx, settings and files
target ACM32F0x0 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: ACM32F0x0 +hex
  AfterMake: fromelf.exe --bin --output rtthread.bin ./build/keil/Obj/acm32f030.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: RT_USING_ARM_LIBC, __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND
  c include: libraries\HAL_Driver\Inc;libraries\Device;libraries\CMSIS;applications;.;..\..\libcpu\arm\common;..\..\libcpu\arm\cortex-m0;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\drivers\include;drivers;..\..\components\finsh;.;..\..\include;..\..\components\libc\compilers\armlibc;..\..\components\libc\compilers\common;..\..\components\libc\compilers\common\nogcc;..\..\examples\utest\testcases\kernel
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\drivers\linker_scripts\link.sct
  group ACM32_HAL
    libraries/HAL_Driver/Src/: HAL_IWDT.c HAL_UART.c HAL_EXTI.c HAL_DMA.c HAL_TIMER.c HAL_ADC.c HAL_WDT.c HAL_GPIO.c
    libraries/Device/: Startup_ACM32F0x0.s System_ACM32F0x0.c
  group Applications
    applications/: main.c
  group CPU
    ../../libcpu/arm/common/: showmem.c backtrace.c div0.c
    ../../libcpu/arm/cortex-m0/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../components/drivers/hwtimer/: hwtimer.c
    ../../components/drivers/misc/: adc.c pin.c
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/src/: ringblk_buf.c waitqueue.c dataqueue.c completion.c pipe.c ringbuffer.c workqueue.c
    ../../components/drivers/watchdog/: watchdog.c
  group Drivers
    drivers/: drv_adc.c drv_wdt.c drv_uart.c drv_gpio.c board.c drv_hwtimer.c
  group Finsh
    ../../components/finsh/: shell.c msh.c
  group Kernel
    ../../src/: irq.c kservice.c thread.c ipc.c scheduler.c idle.c object.c timer.c components.c device.c clock.c mempool.c mem.c
  group libc
    ../../components/libc/compilers/armlibc/: mem_std.c libc.c syscalls.c
    ../../components/libc/compilers/common/: stdlib.c time.c
