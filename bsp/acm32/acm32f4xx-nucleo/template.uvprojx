# Keil uVision project template.uvprojx, settings and files
target ACM32F4XX (6140000::V6.14::ARMCLANG)
  device: ARMCM33_DSP_FP ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ESEL ELITTLE
  output: ACM32F4XX +hex
  AfterMake: fromelf.exe --bin --output ./build/ACM32F4.bin ./build/ACM32F4.axf
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
