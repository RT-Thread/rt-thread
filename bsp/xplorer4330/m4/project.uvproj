# Keil uVision project project.uvproj, settings and files
target project (ARM-ADS)
  device: LPC4330 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1001FFFF) IRAM2(0x20000000-0x2000FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: project
  AfterMake: fromelf --bin -o "$L@L.bin" "$L@L.axf"
  c flags: Optim=1
  c define: CORE_M4
  c include: .;..\..\..\components\CMSIS\Include;..\..\..\components\drivers\include;..\..\..\components\finsh;..\..\..\components\init;..\..\..\include;..\..\..\libcpu\arm\common;..\..\..\libcpu\arm\cortex-m4;..\applications;..\drivers;..\libraries\lpc_board\board_common;..\libraries\lpc_board\boards_18xx_43xx\ngx_xplorer_18304330;..\libraries\lpc_board\boards_18xx_43xx\ngx_xplorer_18304330\ngx_xplorer_4330;..\libraries\lpc_chip\chip_18xx_43xx;..\libraries\lpc_chip\chip_common;..\libraries\lpc_ip
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT9: RAM 0x10000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: .\lpc4330_xplorer_spifi32mb.sct
  link misc: --keep __fsym_* --keep __vsym_*
  group applications
    ../applications/: application.c startup.c
  group drivers
    ../drivers/: platform.c usart.c
  group lpc_board
    ../libraries/lpc_board/boards_18xx_43xx/ngx_xplorer_18304330/: board_ngx_xplorer_18304330.c sysinit_ngx_xplorer_18304330.c
  group lpc_chip
    ../libraries/lpc_chip/chip_18xx_43xx/: adc_18xx_43xx.c atimer_18xx_43xx.c clock_18xx_43xx.c emc_18xx_43xx.c enet_18xx_43xx.c evrt_18xx_43xx.c gpdma_18xx_43xx.c gpio_18xx_43xx.c i2c_18xx_43xx.c i2s_18xx_43xx.c lcd_18xx_43xx.c rgu_18xx_43xx.c ritimer_18xx_43xx.c rtc_18xx_43xx.c scu_18xx_43xx.c sdmmc_18xx_43xx.c ssp_18xx_43xx.c uart_18xx_43xx.c wwdt_18xx_43xx.c
    ../libraries/lpc_chip/chip_common/: mem_tests.c ring_buffer.c
  group lpc_ip
    ../libraries/lpc_ip/: adc_001.c atimer_001.c emc_001.c enet_001.c fpu_init.c gpdma_001.c gpiogrpint_001.c gpioint_001.c gpiopinint_001.c i2c_001.c i2s_001.c lcd_001.c ritimer_001.c rtc_001.c sdmmc_001.c ssp_001.c timer_001.c usart_001.c
  group startup
    ../libraries/startup_code/: keil_startup_lpc18xx43xx.s
  group Kernel
    ../../../src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c thread.c timer.c
  group CORTEX-M4
    ../../../libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
    ../../../libcpu/arm/common/: backtrace.c div0.c showmem.c
  group DeviceDrivers
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/src/: completion.c dataqueue.c pipe.c ringbuffer.c
  group finsh
    ../../../components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c shell.c symbol.c
  group Components
    ../../../components/init/: components.c
