# IAR project at25dfx_unit_test_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMD21J18A Atmel ATSAMD21J18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: BOARD=SAMD21_XPLAINED_PRO; _ASSERT_ENABLE_; ARM_MATH_CM0PLUS=true; TEST_SUITE_DEFINE_ASSERT_MACRO; USART_CALLBACK_MODE=true; __SAMD21J18A__; SPI_CALLBACK_MODE=true
  ICCARM.CCIncludePath2: ../../../../../../../../sam0/utils/cmsis/samd21/source; ../../../hal/spi_master_vec; ../../../../../../../../sam0/drivers/port; ../../../../../../../../sam0/drivers/system/reset; ../../../../../../../../sam0/utils/preprocessor; ..; ../../../../../../../../sam0/drivers/sercom/spi; ../../../../../../../../sam0/utils; ../../../../../../../../sam0/drivers/sercom; ../../../../../../../../sam0/drivers/system/power; ../../../../../../../../sam0/boards; ../../../../../../../../sam0/drivers/sercom/usart; ../../../../../../../../common/services/serial; ../../../../../../../../sam0/drivers/system/clock/clock_samd21_r21_da_ha1; ../../../../../../../../sam0/drivers/system/reset/reset_sam_d_r_h; ../../../../../../../../common/utils; ../../../../../../../../sam0/utils/cmsis/samd21/include; ../../../../../../../../sam0/drivers/system/interrupt/system_interrupt_samd21; ../../../../../../../../sam0/drivers/system/interrupt; ../../../../../../../../sam0/drivers/sercom/spi_master_vec; ../../..; ../../../../../../../../sam0/drivers/system/power/power_sam_d_r_h; ../../../../../../../../common/boards; ../../../../../../../../sam0/drivers/system/pinmux; ../../../../../../../../sam0/drivers/system; ../..; ../../../../../../../../sam0/utils/header_files; ../../../../../../../../sam0/boards/samd21_xplained_pro; ../../../../../../../../sam0/utils/stdio/stdio_serial; ../../../../../../../../sam0/drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: at25dfx_unit_test_flash.bin
  ILINK.IlinkOutputFile: at25dfx_unit_test_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../../sam0/utils/linker_scripts/samd21/iar/samd21j18a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/drivers/sercom
    ../../../../../../../../sam0/drivers/sercom/: sercom_interrupt.c sercom.c sercom_interrupt.h sercom.h sercom_pinout.h
  group sam0/drivers/sercom/usart
    ../../../../../../../../sam0/drivers/sercom/usart/: usart.c usart_interrupt.c usart_interrupt.h usart.h
  group sam0/drivers/sercom/usart/quick_start_callback
    ../../../../../../../../sam0/drivers/sercom/usart/quick_start_callback/: qs_usart_callback.h
  group sam0/drivers/sercom/usart/quick_start
    ../../../../../../../../sam0/drivers/sercom/usart/quick_start/: qs_usart_basic_use.h
  group sam0/drivers/sercom/usart/quick_start_lin
    ../../../../../../../../sam0/drivers/sercom/usart/quick_start_lin/: qs_lin.h
  group sam0/drivers/sercom/usart/quick_start_dma
    ../../../../../../../../sam0/drivers/sercom/usart/quick_start_dma/: qs_usart_dma_use.h
  group sam0/drivers/sercom/spi
    ../../../../../../../../sam0/drivers/sercom/spi/: spi.c spi_interrupt.c spi.h spi_interrupt.h
  group sam0/drivers/sercom/spi/quick_start_master
    ../../../../../../../../sam0/drivers/sercom/spi/quick_start_master/: qs_spi_master_basic.h
  group sam0/drivers/sercom/spi/quick_start_slave_callback
    ../../../../../../../../sam0/drivers/sercom/spi/quick_start_slave_callback/: qs_spi_slave_callback.h
  group sam0/drivers/sercom/spi/quick_start_dma
    ../../../../../../../../sam0/drivers/sercom/spi/quick_start_dma/: qs_spi_dma_use.h
  group sam0/drivers/sercom/spi/quick_start_master_callback
    ../../../../../../../../sam0/drivers/sercom/spi/quick_start_master_callback/: qs_spi_master_callback.h
  group sam0/drivers/sercom/spi/quick_start_slave
    ../../../../../../../../sam0/drivers/sercom/spi/quick_start_slave/: qs_spi_slave_basic.h
  group sam0/drivers/sercom/spi_master_vec
    ../../../../../../../../sam0/drivers/sercom/spi_master_vec/: spi_master_vec.c spi_master_vec.h
  group sam0/drivers/sercom/spi_master_vec/quick_start_basic
    ../../../../../../../../sam0/drivers/sercom/spi_master_vec/quick_start_basic/: qs_spi_master_vec_basic.h
  group sam0/drivers/system
    ../../../../../../../../sam0/drivers/system/: system.c system.h
  group sam0/drivers/system/interrupt
    ../../../../../../../../sam0/drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samd21
    ../../../../../../../../sam0/drivers/system/interrupt/system_interrupt_samd21/: system_interrupt_features.h
  group sam0/drivers/system/pinmux
    ../../../../../../../../sam0/drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../../../../sam0/drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/clock
    ../../../../../../../../sam0/drivers/system/clock/: gclk.h clock.h
  group sam0/drivers/system/clock/clock_samd21_r21_da_ha1
    ../../../../../../../../sam0/drivers/system/clock/clock_samd21_r21_da_ha1/: gclk.c clock.c clock_feature.h clock_config_check.h
  group sam0/drivers/system/power/power_sam_d_r_h
    ../../../../../../../../sam0/drivers/system/power/power_sam_d_r_h/: power.h
  group sam0/drivers/system/reset/reset_sam_d_r_h
    ../../../../../../../../sam0/drivers/system/reset/reset_sam_d_r_h/: reset.h
  group sam0/drivers/port
    ../../../../../../../../sam0/drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../../../../sam0/drivers/port/quick_start/: qs_port_basic.h
  group sam0/utils
    ../../../../../../../../sam0/utils/: compiler.h status_codes.h
  group sam0/utils/stdio
    ../../../../../../../../sam0/utils/stdio/: write.c read.c
  group sam0/utils/stdio/stdio_serial
    ../../../../../../../../sam0/utils/stdio/stdio_serial/: stdio_serial.h
  group sam0/utils/cmsis/samd21/source
    ../../../../../../../../sam0/utils/cmsis/samd21/source/: system_samd21.c system_samd21.h
  group sam0/utils/cmsis/samd21/source/iar
    ../../../../../../../../sam0/utils/cmsis/samd21/source/iar/: startup_samd21.c
  group sam0/utils/cmsis/samd21/include
    ../../../../../../../../sam0/utils/cmsis/samd21/include/: samd21e16l.h samd21j15a.h samd21g16l.h samd21e16bu.h samd21g16a.h samd21j17a.h samd21g16b.h samd21j16a.h samd21j16b.h samd21e17a.h samd21g15a.h samd21g17au.h samd21e18a.h samd21.h samd21g17a.h samd21e16b.h samd21g15l.h samd21e15bu.h samd21g15b.h samd21j15b.h samd21e15b.h samd21g18a.h samd21e16a.h samd21g18au.h samd21e15a.h samd21j18a.h samd21e15l.h
  group sam0/utils/cmsis/samd21/include/pio
    ../../../../../../../../sam0/utils/cmsis/samd21/include/pio/: samd21j16b.h samd21g18au.h samd21j15a.h samd21e16b.h samd21g15a.h samd21g17au.h samd21e18a.h samd21g17a.h samd21j15b.h samd21j16a.h samd21j18a.h samd21g16a.h samd21g16b.h samd21j17a.h samd21g18a.h samd21e16bu.h samd21e15a.h samd21e16l.h samd21e15bu.h samd21g15b.h samd21g15l.h samd21e15l.h samd21g16l.h samd21e17a.h samd21e15b.h samd21e16a.h
  group sam0/utils/cmsis/samd21/include/component
    ../../../../../../../../sam0/utils/cmsis/samd21/include/component/: ac.h evsys.h dsu.h rtc.h pm.h mtb.h hmatrixb.h eic.h pac.h tcc_lighting.h gclk.h wdt.h tcc.h i2s.h tc.h sercom.h dmac.h sysctrl.h usb.h nvmctrl.h port.h dac.h adc.h
  group sam0/utils/cmsis/samd21/include/instance
    ../../../../../../../../sam0/utils/cmsis/samd21/include/instance/: tcc1.h tcc2.h tc3.h pac0.h sbmatrix.h sercom2.h eic.h sercom0.h nvmctrl.h pac2.h usb.h pm.h sercom4.h pac1.h ac.h sercom5.h wdt.h dsu.h mtb.h gclk.h i2s.h tc7.h evsys.h port.h ac1.h sysctrl.h dac.h rtc.h tcc0.h tc6.h tc4.h dmac.h sercom3.h tc5.h sercom1.h adc.h
  group sam0/utils/preprocessor
    ../../../../../../../../sam0/utils/preprocessor/: stringz.h preprocessor.h tpaste.h mrepeat.h mrecursion.h
  group sam0/utils/header_files
    ../../../../../../../../sam0/utils/header_files/: io.h
  group sam0/boards/samd21_xplained_pro
    ../../../../../../../../sam0/boards/samd21_xplained_pro/: board_init.c samd21_xplained_pro.h
  group common2/components/memory/serial_flash/at25dfx
    ../../../: at25dfx.c at25dfx.h
  group common2/components/memory/serial_flash/at25dfx/unit_tests
    ../../: unit_tests.c
  group common2/components/memory/serial_flash/at25dfx/unit_tests/samd21_xplained_pro_vectored_master_spi
    ../: conf_at25dfx.h conf_spi_master_vec.h conf_board.h conf_test.h conf_spi.h conf_clocks.h
  group common2/components/memory/serial_flash/at25dfx/unit_tests/samd21_xplained_pro_vectored_master_spi/iar
    ./: asf.h
  group common2/components/memory/serial_flash/at25dfx/hal/spi_master_vec
    ../../../hal/spi_master_vec/: at25dfx_priv_hal.h at25dfx_hal.h
  group common2/components/memory/serial_flash/at25dfx/quick_start_basic
    ../../../quick_start_basic/: qs_at25dfx_basic.h
  group common/utils
    ../../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/unit_test
    ../../../../../../../../common/utils/unit_test/: suite.c suite.h
  group common/utils/interrupt
    ../../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/serial
    ../../../../../../../../common/services/serial/: serial.h
  group common/services/serial/sam0_usart
    ../../../../../../../../common/services/serial/sam0_usart/: usart_serial.h
  group common/boards
    ../../../../../../../../common/boards/: board.h
