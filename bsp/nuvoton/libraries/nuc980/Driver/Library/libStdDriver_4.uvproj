# Keil uVision project libStdDriver_4.uvproj, settings and files
target libStdDriver_4 (ARM-ADS)
  device: Nuvoton_ARM9_Series Nuvoton
  output: libstddriver_keil4 +hex (library)
  AfterMake: xcopy /y ".\build\keil4\@L.lib" "."
  c flags: Optim=1
  c misc: --c99
  c include: ..\Library;..\Include
  group src
    ../Source/: nu_can.c nu_cap.c nu_crypto.c nu_ebi.c nu_emac.c nu_etimer.c nu_gpio.c nu_i2c.c nu_i2s.c nu_pdma.c nu_qspi.c nu_rtc.c nu_scuart.c nu_sdh.c nu_spi.c nu_sys.c nu_uart.c nu_usbd.c nu_wdt.c nu_wwdt.c
