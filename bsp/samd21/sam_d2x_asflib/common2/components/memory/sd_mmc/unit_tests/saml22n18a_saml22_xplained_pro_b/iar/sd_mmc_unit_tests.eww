<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\sd_mmc_unit_tests_flash.ewp</path>
	</project>
</workspace>
