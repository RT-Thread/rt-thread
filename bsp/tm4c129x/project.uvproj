# Keil uVision project project.uvproj, settings and files
target RT-Thread TM4C129X (ARM-ADS)
  device: TM4C1294NCPDT Texas Instruments
  pack: Keil.TM4C_DFP.1.0.0
  cpu: IROM(0x00000000,0x100000) IRAM(0x20000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(120000000) ELITTLE
  output: rtthread-tm4c
  c flags: Optim=1 wLevel=2
  c define: __STDC_LIMIT_MACROS, RT_USING_ARMLIBC, RT_USING_LIBC, PART_TM4C129XNCZAD, __CLK_TCK=RT_TICK_PER_SECOND, __RTTHREAD__
  c include: libraries;..\..\components\libc\compilers\common\extension;..\..\components\drivers\include;..\..\libcpu\arm\cortex-m4;libraries\driverlib;..\..\components\finsh;libraries\inc;applications;..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\components\libc\posix\io\stdio;drivers;..\..\components\net\lwip\lwip-1.4.1\src\include\ipv4;..\..\components\net\lwip\lwip-1.4.1\src\include\netif;..\..\include;..\..\components\drivers\include;..\..\libcpu\arm\common;..\..\components\net\lwip\port;..\..\components\libc\posix\ipc;.;..\..\components\net\lwip\lwip-1.4.1\src\include;..\..\components\libc\posix\io\poll;..\..\components\libc\compilers\common\include
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: tm4c_rom.sct
  group Applications
    applications/: board.c application.c
  group Compiler
    ../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../components/libc/compilers/common/: cctype.c cstdio.c cstdlib.c cstring.c ctime.c cwchar.c
  group CPU
    ../../libcpu/arm/common/: div0.c showmem.c
    ../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../components/drivers/serial/: serial.c
  group Drivers
    drivers/: drv_uart.c drv_eth.c
  group Finsh
    ../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler_up.c thread.c timer.c
  group Libraries
    libraries/driverlib/: ssi.c interrupt.c crc.c udma.c comp.c usb.c shamd5.c des.c flash.c uart.c can.c onewire.c qei.c adc.c mpu.c i2c.c systick.c cpu.c pwm.c watchdog.c eeprom.c gpio.c sysctl.c epi.c lcd.c tiva_timer.c sw_crc.c emac.c fpu.c aes.c sysexc.c hibernate.c
    libraries/startup/: startup_rvmdk.S
  group lwIP
    ../../components/net/lwip/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../components/net/lwip/lwip-1.4.1/src/apps/ping/: ping.c
    ../../components/net/lwip/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../../components/net/lwip/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../components/net/lwip/lwip-1.4.1/src/netif/: etharp.c slipif.c
    ../../components/net/lwip/port/: ethernetif.c sys_arch.c
