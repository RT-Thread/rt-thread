# Keil uVision project project.uvproj, settings and files
target LPC43xx SPIFI (ARM-ADS)
  device: LPC4357 CM0 NXP
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: rtthread_lpc43xx
  AfterMake: fromelf --bin !L --output rtthread.bin
  AfterMake: C:\Python27\python.exe ..\bin2C.py rtthread.bin ..\M4\applications\M0_CODE.h
  c flags: Optim=1 OneElfS=1
  c define: CORE_M0, USE_SPIFI, __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND
  c include: applications;.;..\Libraries\Device\NXP\LPC43xx\Include;..\Libraries\CMSIS\Include;..\..\..\libcpu\arm\common;..\..\..\libcpu\arm\cortex-m0;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\drivers;..\..\..\components\finsh;.;..\..\..\include;..\..\..\components\libc\compilers\common;..\..\..\components\libc\compilers\common\nogcc;..\..\..\examples\utest\testcases\kernel;..\..\..\components\vbus;..\..\..\components\vbus\share_hdr
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT1: ROM 0x14000000 size 0x400000
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: .\rtthread_lpc43xx.sct
  group Applications
    applications/: vbus_drv.c startup.c application.c board.c
  group CMSIS
    ../Libraries/Device/NXP/LPC43xx/Source/Templates/: system_LPC43xx.c
    ../Libraries/Device/NXP/LPC43xx/Source/Templates/ARM/: startup_LPC43xx_M0.s
  group CPU
    ../../../libcpu/arm/common/: div0.c backtrace.c showmem.c
    ../../../libcpu/arm/cortex-m0/: cpuport.c context_rvds.S
  group DeviceDrivers
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/src/: workqueue.c waitqueue.c ringblk_buf.c pipe.c dataqueue.c ringbuffer.c completion.c
  group Drivers
    ../drivers/: drv_led.c drv_uart.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c
  group Kernel
    ../../../src/: irq.c device.c components.c memheap.c kservice.c timer.c ipc.c idle.c mem.c thread.c object.c scheduler.c mempool.c clock.c
  group VBus
    ../../../components/vbus/: prio_queue.c watermark_queue.c vbus_chnx.c vbus.c
