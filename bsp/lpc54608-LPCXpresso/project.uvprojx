# Keil uVision project project.uvprojx, settings and files
target rtthread-lpc546xx (ARM-ADS)
  device: LPC54608J512ET180:M4 NXP
  pack: Keil.LPC54000_DFP.2.5.0
  cpu: IROM(0x00000000,0x00080000) IRAM(0x20000000,0x00028000) IRAM2(0x04000000,0x00008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rtthread-lpc546xx
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: CPU_LPC54608J512ET180=1, CPU_LPC54608, CORE_M4, SDK_DEBUGCONSOLE=0, RT_USING_ARM_LIBC
  c misc: --library_interface=armcc --library_type=standardlib --diag_suppress=66,1296,186
  c include: .;..\..\include;applications;.;drivers;SDK_2.2_LPCXpresso54608\CMSIS\Include;SDK_2.2_LPCXpresso54608\devices\LPC54608;SDK_2.2_LPCXpresso54608\devices\LPC54608\drivers;SDK_2.2_LPCXpresso54608\devices\LPC54608\utilities;SDK_2.2_LPCXpresso54608\sdmmc_2.1.2\inc;SDK_2.2_LPCXpresso54608\sdmmc_2.1.2\src;..\..\libcpu\arm\common;..\..\libcpu\arm\cortex-m4;..\..\components\cplusplus;..\..\components\dfs\include;..\..\components\dfs\filesystems\devfs;..\..\components\dfs\filesystems\elmfat;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\drivers\spi;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\finsh;..\..\components\libc\compilers\armlibc;..\..\components\libc\compilers\common;..\..\components\libc\pthreads;..\..\components\libc\time;..\..\components\net\lwip-2.0.2\src;..\..\components\net\lwip-2.0.2\src\include;..\..\components\net\lwip-2.0.2\src\include\ipv4;..\..\components\net\lwip-2.0.2\src\arch\include;..\..\components\net\lwip-2.0.2\src\include\netif;..\..\components\net\netdev\include;..\..\components\net\sal_socket\include;..\..\components\net\sal_socket\include\socket;..\..\components\net\sal_socket\impl;..\..\components\net\sal_socket\include\dfs_net;..\..\components\net\sal_socket\include\dfs_net\sys_select;..\..\components\net\sal_socket\include\socket\sys_socket
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: .\LPC54608J512_flash.scf
  group Kernel
    ../../src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group Applications
    applications/: application.c mnt.c startup.c
  group Drivers
    drivers/: board.c clock_config.c drt_mpu.c drv_emac.c drv_ft5406.c drv_i2c.c drv_lcd.c drv_sd.c drv_sdram.c drv_sram.c drv_uart.c fsl_phy.c
  group CMSIS
    SDK_2.2_LPCXpresso54608/devices/LPC54608/arm/: startup_LPC54608.s keil_lib_power.lib
    SDK_2.2_LPCXpresso54608/devices/LPC54608/: system_LPC54608.c
  group Libraries
    SDK_2.2_LPCXpresso54608/devices/LPC54608/drivers/: fsl_adc.c fsl_clock.c fsl_common.c fsl_crc.c fsl_ctimer.c fsl_dma.c fsl_dmic.c fsl_dmic_dma.c fsl_eeprom.c fsl_emc.c fsl_enet.c fsl_flashiap.c fsl_flexcomm.c fsl_fmc.c fsl_fmeas.c fsl_gint.c fsl_gpio.c fsl_i2c.c fsl_i2c_dma.c fsl_i2s.c fsl_i2s_dma.c fsl_inputmux.c fsl_lcdc.c fsl_mcan.c fsl_mrt.c fsl_pint.c fsl_power.c fsl_reset.c fsl_rit.c fsl_rtc.c fsl_sctimer.c fsl_sdif.c fsl_spi.c fsl_spi_dma.c fsl_spifi.c fsl_spifi_dma.c fsl_usart.c fsl_usart_dma.c fsl_utick.c fsl_wwdt.c
    SDK_2.2_LPCXpresso54608/sdmmc_2.1.2/src/: fsl_sd.c fsl_sdmmc.c fsl_host.c fsl_sd_event.c
  group cpu
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
  group CPlusPlus
    ../../components/cplusplus/: Mutex.cpp Semaphore.cpp Thread.cpp crt.cpp crt_init.c
  group Filesystem
    ../../components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c poll.c select.c
    ../../components/dfs/filesystems/devfs/: devfs.c
    ../../components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
  group DeviceDrivers
    ../../components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    ../../components/drivers/misc/: pin.c
    ../../components/drivers/mtd/: mtd_nand.c
    ../../components/drivers/rtc/: rtc.c
    ../../components/drivers/sdio/: block_dev.c mmcsd_core.c sd.c sdio.c mmc.c
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/spi/: spi_core.c spi_dev.c
    ../../components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
  group finsh
    ../../components/finsh/: shell.c symbol.c cmd.c msh.c msh_cmd.c msh_file.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_var.c finsh_vm.c finsh_token.c
  group libc
    ../../components/libc/compilers/armlibc/: libc.c mem_std.c stdio.c stubs.c time.c
    ../../components/libc/compilers/common/: gmtime_r.c
  group pthreads
    ../../components/libc/pthreads/: mqueue.c pthread.c pthread_attr.c pthread_barrier.c pthread_cond.c pthread_mutex.c pthread_rwlock.c pthread_spin.c pthread_tls.c sched.c semaphore.c
    ../../components/libc/time/: clock_time.c posix_sleep.c
  group lwIP
    ../../components/net/lwip-2.0.2/src/arch/: sys_arch.c
    ../../components/net/lwip-2.0.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../components/net/lwip-2.0.2/src/core/: def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../components/net/lwip-2.0.2/src/netif/: ethernet.c ethernetif.c lowpan6.c
    ../../components/net/lwip-2.0.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../components/net/lwip-2.0.2/src/apps/ping/: ping.c
  group netdev
    ../../components/net/netdev/src/: netdev.c netdev_ipaddr.c
  group SAL
    ../../components/net/sal_socket/src/: sal_socket.c
    ../../components/net/sal_socket/socket/: net_netdb.c net_sockets.c
    ../../components/net/sal_socket/impl/: af_inet_lwip.c
    ../../components/net/sal_socket/dfs_net/: dfs_net.c
