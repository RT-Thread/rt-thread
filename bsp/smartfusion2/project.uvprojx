# Keil uVision project project.uvprojx, settings and files
target project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: M2S010 Microsemi
  pack: Microsemi.M2Sxxx.1.0.64
  cpu: IRAM(0x20000000,0x10000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rtthread +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __STDC_LIMIT_MACROS, __RTTHREAD__, RT_USING_LIBC, RT_USING_ARMLIBC, __CLK_TCK=RT_TICK_PER_SECOND
  c include: ..\..\components\drivers\include;..\..\components\libc\posix\ipc;..\..\components\libc\posix\io\poll;CMSIS;..\..\components\net\utest;..\..\components\drivers\smp_call;..\..\components\drivers\include;..\..\components\libc\compilers\common\extension;..\..\components\libc\posix\io\eventfd;..\..\components\libc\posix\io\epoll;drivers;..\..\components\drivers\include;..\..\components\finsh;..\..\libcpu\arm\cortex-m3;libraries\sys_config;..\..\components\libc\compilers\common\extension\fcntl\octal;libraries\mss_uart;..\..\components\drivers\phy;..\..\libcpu\arm\common;.;..\..\components\libc\compilers\common\include;..\..\include;libraries\mss_gpio;..\..\components\drivers\include;applications;..\..\components\drivers\include;board;..\..\components\drivers\include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\applications\link.sct
  group Applications
    applications/: main.c
    board/: board.c config.c
  group CMSIS
    CMSIS/: core_cm3.c system_m2sxxx.c
    CMSIS/startup_arm/: startup_m2sxxx.s
  group CPU
    ../../libcpu/arm/common/: div0.c showmem.c
    ../../libcpu/arm/cortex-m3/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../components/drivers/core/: device.c
    ../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../components/drivers/pin/: dev_pin.c
    ../../components/drivers/serial/: dev_serial.c
  group Drivers
    drivers/: drv_uart.c drv_gpio.c
  group Finsh
    ../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group Libc
    ../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
  group Libraries
    libraries/sys_config/: sys_config.c
    libraries/mss_gpio/: mss_gpio.c
    libraries/mss_uart/: mss_uart.c
