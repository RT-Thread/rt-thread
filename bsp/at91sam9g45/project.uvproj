# Keil uVision project project.uvproj, settings and files
target rtthread (ARM-ADS)
  device: AT91SAM9260 Atmel
  cpu: IRAM(0x200000-0x200FFF) IRAM2(0x300000-0x300FFF) IROM(0x100000-0x107FFF) CLOCK(18432000) CPUTYPE(ARM926EJ-S)
  output: rtthread
  c flags: Optim=1 wLevel=2
  c define: RT_USING_ARM_LIBC, __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND
  c include: applications;.;..\..\components\cplusplus;..\..\libcpu\arm\common;..\..\libcpu\arm\arm926;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\drivers\include;drivers;..\..\components\dfs\include;..\..\components\dfs\filesystems\devfs;..\..\components\finsh;.;..\..\include;..\..\components\libc\compilers\armlibc;..\..\components\libc\compilers\common;..\..\components\libc\compilers\common\nogcc;..\..\components\libc\pthreads;platform;..\..\examples\utest\testcases\kernel
  asm include: .\platform
  memory RVCT1: ROM 0x20000000 size 0x800000
  memory RVCT4: ROM 0x100000 size 0x8000
  memory RVCT6: RAM 0x20800000 size 0x1800000
  memory RVCT9: RAM 0x200000 size 0x1000
  memory RVCT10: RAM 0x300000 size 0x1000
  scatter file: .\link_scripts\at91sam9g45_ram.scat
  group Applications
    applications/: application.c
  group CPlusPlus
    ../../components/cplusplus/: cxx_crt_init.c cxx_Mutex.cpp cxx_Semaphore.cpp cxx_crt.cpp cxx_Thread.cpp
  group CPU
    ../../libcpu/arm/common/: showmem.c backtrace.c div0.c
    ../../libcpu/arm/arm926/: context_rvds.S cpuport.c stack.c mmu.c start_rvds.S trap.c machine.c
  group DeviceDrivers
    ../../components/drivers/misc/: pin.c
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/src/: pipe.c dataqueue.c workqueue.c ringbuffer.c completion.c ringblk_buf.c waitqueue.c
  group Drivers
    drivers/: usart.c board.c led.c
  group Filesystem
    ../../components/dfs/src/: dfs_posix.c dfs_fs.c dfs.c dfs_file.c
    ../../components/dfs/filesystems/devfs/: devfs.c
  group Finsh
    ../../components/finsh/: shell.c msh.c msh_file.c
  group Kernel
    ../../src/: components.c kservice.c mem.c irq.c timer.c device.c object.c idle.c mempool.c scheduler.c clock.c thread.c ipc.c
  group libc
    ../../components/libc/compilers/armlibc/: mem_std.c stdio.c syscalls.c libc.c
    ../../components/libc/compilers/common/: stdlib.c time.c
    ../../components/libc/pthreads/: pthread.c pthread_mutex.c sched.c pthread_barrier.c pthread_rwlock.c pthread_cond.c pthread_spin.c mqueue.c pthread_tls.c semaphore.c pthread_attr.c
  group Platform
    platform/: reset.c system_clock.c interrupt.c rt_low_level_init.c
