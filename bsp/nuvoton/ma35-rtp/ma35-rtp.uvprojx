# Keil uVision project ma35-rtp.uvprojx, settings and files
target rtthread-subm (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: rtthread +hex
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  AfterMake: fromelf --text -c "$L@L.axf" --output "$L@L.txt"
  c flags: Optim=3 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: RT_USING_LIBC, __RTTHREAD__, __STDC_LIMIT_MACROS, RT_USING_ARM_LIBC, __CLK_TCK=RT_TICK_PER_SECOND
  c include: ..\..\..\components\libc\compilers\common\extension;..\..\..\components\libc\posix\io\stdio;..\..\..\libcpu\arm\common;..\..\..\components\drivers\include;..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\libraries\ma35\CMSIS\Include;..\..\..\examples\utest\testcases\utest;board\nutool_pincfg;..\libraries\ma35\Device\Nuvoton\MA35D1\Include;..\..\..\components\finsh;..\..\..\components\utilities\utest;..\libraries\ma35\StdDriver\inc;..\..\..\examples\utest\testcases\kernel;..\..\..\components\drivers\include;..\libraries\ma35\rtt_port;..\..\..\components\libc\posix\ipc;..\libraries\nu_packages\TPC;board;..\..\..\components\drivers\include;..\..\..\components\libc\posix\io\poll;.;test\template;..\..\..\include;..\..\..\libcpu\arm\cortex-m4;applications;..\libraries\ma35\libcpu\arm\cortex-m4;..\..\..\components\libc\compilers\common\include;..\..\..\components\utilities\ulog;..\libraries\nu_packages\NuUtils\inc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Applications
    applications/: main.c mnt.c
  group board
    board/: board_dev.c
    board/nutool_pincfg/: nutool_pincfg.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdio.c cstdlib.c cstring.c ctime.c cwchar.c
  group CPU
    ../../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
    ../libraries/ma35/libcpu/arm/cortex-m4/: interrupt.c
  group DeviceDrivers
    ../../../components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/serial/: serial.c
  group Drivers
    ../libraries/ma35/Device/Nuvoton/MA35D1/Source/ARM/: startup_ma35d1_subm.s
    ../libraries/ma35/Device/Nuvoton/MA35D1/Source/: system_ma35d1_subm.c
    ../libraries/ma35/rtt_port/: drv_adc.c drv_canfd.c drv_ccap.c drv_common.c drv_disp.c drv_eadc.c drv_ecap.c drv_epwm.c drv_epwm_capture.c drv_gpio.c drv_i2c.c drv_i2s.c drv_pdma.c drv_qei.c drv_qspi.c drv_rtc.c drv_rtp.c drv_scuart.c drv_sdio.c drv_softi2c.c drv_spi.c drv_spii2s.c drv_sys.c drv_sys_i2c0.c drv_timer.c drv_tpwm.c drv_uart.c drv_usbhost.c drv_wdt.c nu_clock_init.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group Libraries
    ../libraries/ma35/StdDriver/src/: nu_sc.c nu_wdt.c nu_ccap.c nu_clk.c nu_i2s.c nu_eadc.c nu_ebi.c nu_scuart.c nu_rtc.c nu_pdma.c nu_i2c.c nu_epwm.c nu_spi.c nu_sys.c nu_wwdt.c nu_sdh.c nu_adc.c nu_uart.c nu_timer.c nu_kpi.c nu_ssmcc.c nu_qei.c nu_qspi.c nu_canfd.c nu_gpio.c nu_sspcc.c nu_timer_pwm.c nu_ecap.c nu_disp.c nu_whc.c
  group UTest
    ../../../components/utilities/utest/: utest.c
  group utestcases
    test/template/: utest_template.c
    ../../../examples/utest/testcases/kernel/: mem_tc.c
    ../../../examples/utest/testcases/utest/: pass_tc.c
  group Utilities
    ../../../components/utilities/ulog/: ulog.c
    ../../../components/utilities/ulog/backend/: console_be.c
