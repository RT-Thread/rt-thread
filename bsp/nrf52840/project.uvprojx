# Keil uVision project project.uvprojx, settings and files
target rtthread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.28.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NRF52840_XXAA, SWI_DISABLE0, SOFTDEVICE_PRESENT, CONFIG_NFCT_PINS_AS_GPIOS, FLOAT_ABI_HARD, S140, BLE_STACK_SUPPORT_REQD, NRF_SD_BLE_API_VERSION=6, RT_USING_ARM_LIBC
  c misc: --reduce_paths
  c include: .;..\..\include;applications;.;board;packages\netutils-v1.1.0\ntp;packages\netutils-v1.1.0\telnet;packages\nrf5_sdk-latest;packages\nrf5_sdk-latest\modules\nrfx;packages\nrf5_sdk-latest\modules\nrfx\hal;packages\nrf5_sdk-latest\modules\nrfx\mdk;packages\nrf5_sdk-latest\modules\nrfx\drivers\include;packages\nrf5_sdk-latest\integration\nrfx;packages\nrf5_sdk-latest\integration\nrfx\legacy;packages\nrf5_sdk-latest\integration\nrfx;packages\nrf5_sdk-latest\components;packages\nrf5_sdk-latest\components\toolchain\arm;packages\nrf5_sdk-latest\components\toolchain\cmsis\include;packages\nrf5_sdk-latest\components\device;packages\nrf5_sdk-latest\components\ble;packages\nrf5_sdk-latest\components\ble\common;packages\nrf5_sdk-latest\components\ble\nrf_ble_gatt;packages\nrf5_sdk-latest\components\ble\ble_advertising;packages\nrf5_sdk-latest\components\ble\ble_services\ble_nus;packages\nrf5_sdk-latest\components\ble\ble_link_ctx_manager;packages\nrf5_sdk-latest\components\libraries\util;packages\nrf5_sdk-latest\components\libraries\timer;packages\nrf5_sdk-latest\components\libraries\experimental_section_vars;packages\nrf5_sdk-latest\components\libraries\atomic;packages\nrf5_sdk-latest\components\libraries\atomic_flags;packages\nrf5_sdk-latest\components\libraries\log;packages\nrf5_sdk-latest\components\libraries\log\src;packages\nrf5_sdk-latest\components\libraries\strerror;packages\nrf5_sdk-latest\components\softdevice\common;packages\nrf5_sdk-latest\components\softdevice\s140\headers;packages\nrf5_sdk-latest\components\softdevice\s140\headers\nrf52;packages\wiznet-latest\inc;packages\wiznet-latest\ioLibrary;packages\wiznet-latest\ioLibrary\Ethernet;packages\wiznet-latest\ioLibrary\Internet;startups;..\..\libcpu\arm\common;..\..\libcpu\arm\cortex-m4;..\..\components\dfs\include;..\..\components\dfs\filesystems\devfs;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\drivers\spi;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\finsh;..\..\components\libc\compilers\armlibc;..\..\components\libc\compilers\common;..\..\components\net\netdev\include;..\..\components\net\sal_socket\include;..\..\components\net\sal_socket\include\socket;..\..\components\net\sal_socket\include\dfs_net;..\..\components\net\sal_socket\include\dfs_net\sys_select;..\..\components\net\sal_socket\include\socket\sys_socket
  asm define: CONFIG_NFCT_PINS_AS_GPIOS FLOAT_ABI_HARD NRF52840_XXAA BLE_STACK_SUPPORT_REQD NRF_SD_BLE_API_VERSION=6 S140 SOFTDEVICE_PRESENT SWI_DISABLE0
  asm misc: --cpreproc_opts=-DCONFIG_NFCT_PINS_AS_GPIOS,-DFLOAT_ABI_HARD,-DNRF52840_XXAA,-DBLE_STACK_SUPPORT_REQD,-DNRF_SD_BLE_API_VERSION=6,-DS140,-DSOFTDEVICE_PRESENT,-DSWI_DISABLE0
  memory RVCT4: ROM 0x26000 size 0xb8000
  memory RVCT9: RAM 0x20002d18 size 0x3d2e8
  group Kernel
    ../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group Applications
    applications/: application.c ble_app_init.c startup.c
  group Board
    board/: board.c rt_nrf_gpio.c rt_nrf_spi.c rt_nrf_uart.c
  group NetUtils
    packages/netutils-v1.1.0/ntp/: ntp.c
    packages/netutils-v1.1.0/telnet/: telnet.c
  group nRF_Drivers
    packages/nrf5_sdk-latest/modules/nrfx/drivers/src/: nrfx_clock.c nrfx_spi.c
    packages/nrf5_sdk-latest/integration/nrfx/legacy/: nrf_drv_clock.c nrf_drv_spi.c
  group nRF_BLE
    packages/nrf5_sdk-latest/components/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
    packages/nrf5_sdk-latest/components/ble/nrf_ble_gatt/: nrf_ble_gatt.c
    packages/nrf5_sdk-latest/components/ble/ble_services/ble_nus/: ble_nus.c
    packages/nrf5_sdk-latest/components/ble/ble_advertising/: ble_advertising.c
    packages/nrf5_sdk-latest/components/ble/ble_link_ctx_manager/: ble_link_ctx_manager.c
  group nRF_Libraries
    packages/nrf5_sdk-latest/components/libraries/queue/: nrf_queue.c
    packages/nrf5_sdk-latest/components/libraries/experimental_section_vars/: nrf_section_iter.c
    packages/nrf5_sdk-latest/components/libraries/atomic/: nrf_atomic.c
    packages/nrf5_sdk-latest/components/libraries/atomic_flags/: nrf_atflags.c
    packages/nrf5_sdk-latest/components/libraries/timer/: app_timer_rtthread.c
    packages/nrf5_sdk-latest/components/libraries/util/: app_error.c app_error_handler_keil.c app_error_weak.c app_util_platform.c nrf_assert.c sdk_mapped_flags.c
  group nRF_SOFTDEVICE
    packages/nrf5_sdk-latest/components/softdevice/common/: nrf_sdh.c nrf_sdh_ble.c nrf_sdh_rtthread.c nrf_sdh_soc.c
  group WIZnet
    packages/wiznet-latest/src/: wiz_af_inet.c wiz_device.c wiz_socket.c wiz.c wiz_ping.c
    packages/wiznet-latest/ioLibrary/Ethernet/: wizchip_conf.c wizchip_socket.c
    packages/wiznet-latest/ioLibrary/Internet/DNS/: wizchip_dns.c
    packages/wiznet-latest/ioLibrary/Internet/DHCP/: wizchip_dhcp.c
    packages/wiznet-latest/ioLibrary/Ethernet/W5500/: w5500.c
  group Startup
    startups/: system_nrf52840.c
    startups/arm/: arm_startup_nrf52840.s
  group cpu
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
  group Filesystem
    ../../components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c poll.c select.c
    ../../components/dfs/filesystems/devfs/: devfs.c
  group DeviceDrivers
    ../../components/drivers/misc/: pin.c
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/spi/: spi_core.c spi_dev.c
    ../../components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
  group finsh
    ../../components/finsh/: shell.c cmd.c msh.c msh_file.c
  group libc
    ../../components/libc/compilers/armlibc/: libc.c mem_std.c stdio.c stubs.c
    ../../components/libc/compilers/common/: time.c
  group netdev
    ../../components/net/netdev/src/: netdev.c netdev_ipaddr.c
  group SAL
    ../../components/net/sal_socket/src/: sal_socket.c
    ../../components/net/sal_socket/socket/: net_netdb.c net_sockets.c
    ../../components/net/sal_socket/dfs_net/: dfs_net.c
