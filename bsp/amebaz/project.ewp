# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CONFIG_PLATFORM_8711B; CONFIG_BUILD_ROM; PLATFORM_RTTHREAD; __IEEE_LITTLE_ENDIAN; RT_USING_DLIBC; _DLIB_FILE_DESCRIPTOR; _DLIB_THREAD_SUPPORT; CONFIG_PLATFORM_8711B; PLATFORM_RTTHREAD; __IEEE_LITTLE_ENDIAN; CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; __RTTHREAD__; __RT_IPC_SOURCE__; __RT_KERNEL_SOURCE__
  ICCARM.CCDiagSuppress: Be006,Pa050,Pa039,Pa089,Pe014,Pe047,Pe068,Pe089,Pe167,Pe177,Pe186,Pe188,Pe375,Pe550,Pe550,Pe223,Pe549,Pe550
  ICCARM.IExtraOptions: --enum_is_int
  ICCARM.CCIncludePath2: packages\realtek_ameba-latest\sdk-ameba-v4.0b_without_NDA_GCC_V1.0.0\component\common\api; packages\realtek_ameba-latest\sdk-ameba-v4.0b_without_NDA_GCC_V1.0.0\component\common\drivers\wlan\realtek\wlan_ram_map\rom; packages\realtek_ameba-latest\sdk-ameba-v4.0b_without_NDA_GCC_V1.0.0\component\soc\realtek\8711b\misc; packages\realtek_ameba-latest\sdk-ameba-v4.0b_without_NDA_GCC_V1.0.0\component\common\api\platform; packages\realtek_ameba-latest\rtthread_patch; packages\realtek_ameba-latest\rtthread_patch\realtek\8711b\include; ..\..\include; ..\..\components\net\lwip\lwip-2.0.3\src\include\posix; packages\realtek_ameba-latest\sdk-ameba-v4.0b_without_NDA_GCC_V1.0.0\component\soc\realtek\8711b\app\monitor\include; ..\..\components\drivers\include; packages\realtek_ameba-latest\sdk-ameba-v4.0b_without_NDA_GCC_V1.0.0\component\os\freertos\freertos_v8.1.2\Source\include; packages\realtek_ameba-latest\sdk-ameba-v4.0b_without_NDA_GCC_V1.0.0\component\os\os_dep\include; packages\realtek_ameba-latest\sdk-ameba-v4.0b_without_NDA_GCC_V1.0.0\component\common\api\wifi\rtw_wpa_supplicant\src; ..\..\components\libc\posix\io\poll; ..\..\components\libc\posix\ipc; ..\..\components\net\lwip-dhcpd; drivers; ..\..\components\net\lwip\lwip-2.0.3\src\include\netif; ..\..\libcpu\arm\cortex-m4; .; packages\realtek_ameba-latest\sdk-ameba-v4.0b_without_NDA_GCC_V1.0.0\component\common\drivers\wlan\realtek\include; ..\..\components\net\lwip\lwip-2.0.3\src\include; packages\realtek_ameba-latest\sdk-ameba-v4.0b_without_NDA_GCC_V1.0.0\component\soc\realtek\8711b\cmsis\device; ..\..\components\libc\compilers\common\extension\fcntl\octal; packages\realtek_ameba-latest\sdk-ameba-v4.0b_without_NDA_GCC_V1.0.0\component\soc\realtek\8711b\swlib\std_lib\libc\rom\string; packages\realtek_ameba-latest\sdk-ameba-v4.0b_without_NDA_GCC_V1.0.0\component\common\mbed\hal; ..\..\components\libc\posix\io\eventfd; packages\realtek_ameba-latest\sdk-ameba-v4.0b_without_NDA_GCC_V1.0.0\component\common\mbed\hal_ext; packages\realtek_ameba-latest\sdk-ameba-v4.0b_without_NDA_GCC_V1.0.0\component\soc; ..\..\components\libc\compilers\common\include; packages\realtek_ameba-latest\sdk-ameba-v4.0b_without_NDA_GCC_V1.0.0\component\os\freertos; applications; packages\realtek_ameba-latest\sdk-ameba-v4.0b_without_NDA_GCC_V1.0.0\component\common\network\ssl\polarssl-1.3.8\include; drivers\wlan; packages\realtek_ameba-latest\sdk-ameba-v4.0b_without_NDA_GCC_V1.0.0\component\os\freertos\freertos_v8.1.2\Source\portable\IAR\ARM_CM4F; ..\..\components\net\lwip\lwip-2.0.3\src\include\ipv4; ..\..\components\net\lwip\port; ..\..\components\finsh; packages\realtek_ameba-latest\sdk-ameba-v4.0b_without_NDA_GCC_V1.0.0\component\soc\realtek\8711b\cmsis; packages\realtek_ameba-latest\sdk-ameba-v4.0b_without_NDA_GCC_V1.0.0\component\soc\realtek\8711b\swlib\rtl_lib; packages\realtek_ameba-latest\rtthread_patch\os; ..\..\components\drivers\wlan; ..\..\components\libc\compilers\common\extension; packages\realtek_ameba-latest\sdk-ameba-v4.0b_without_NDA_GCC_V1.0.0\component\soc\realtek\8711b\fwlib\include; packages\realtek_ameba-latest\sdk-ameba-v4.0b_without_NDA_GCC_V1.0.0\component\common\drivers\wlan\realtek\src\osdep; packages\realtek_ameba-latest\sdk-ameba-v4.0b_without_NDA_GCC_V1.0.0\component\common\network\ssl\ssl_ram_map\rom; packages\realtek_ameba-latest\sdk-ameba-v4.0b_without_NDA_GCC_V1.0.0\component\soc\realtek\8711b\swlib\std_lib\include; packages\realtek_ameba-latest\sdk-ameba-v4.0b_without_NDA_GCC_V1.0.0\component\common\api\wifi; ..\..\components\libc\posix\io\epoll; ..\..\libcpu\arm\common; libraries\smartconfig\inc; packages\realtek_ameba-latest\sdk-ameba-v4.0b_without_NDA_GCC_V1.0.0\component\common\mbed\api; packages\realtek_ameba-latest\sdk-ameba-v4.0b_without_NDA_GCC_V1.0.0\component\common\mbed\targets\hal\rtl8711b
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: template.srec
  prebuild: CSCRIPT  "packages\realtek_ameba-latest\sdk-ameba-v4.0b_without_NDA_GCC_V1.0.0\component\soc\realtek\8711b\misc\iar_utility\common\prebuild.vbs" "$PROJ_DIR$" "1" "0x08080000"
  postbuild: CSCRIPT  "packages\realtek_ameba-latest\sdk-ameba-v4.0b_without_NDA_GCC_V1.0.0\component\soc\realtek\8711b\misc\iar_utility\common\postbuild_img2.vbs" "$TARGET_DIR$" "$PROJ_DIR$"
  ILINK.IlinkOutputFile: application.axf
  ILINK.IlinkKeepSymbols: bootloader
  ILINK.IlinkIcfFile: image2.icf
  ILINK.IlinkAdditionalLibs: packages\realtek_ameba-latest\sdk-ameba-v4.0b_without_NDA_GCC_V1.0.0\component\soc\realtek\8711b\misc\bsp\lib\common\IAR\lib_platform.a; packages\realtek_ameba-latest\sdk-ameba-v4.0b_without_NDA_GCC_V1.0.0\component\soc\realtek\8711b\misc\bsp\lib\common\IAR\lib_rtlstd.a; packages\realtek_ameba-latest\sdk-ameba-v4.0b_without_NDA_GCC_V1.0.0\component\soc\realtek\8711b\misc\bsp\lib\common\IAR\lib_wlan.a; packages\realtek_ameba-latest\sdk-ameba-v4.0b_without_NDA_GCC_V1.0.0\component\soc\realtek\8711b\misc\bsp\lib\common\IAR\lib_wps.a; libraries\smartconfig\libs\libsmartconfig_armcm4_iar.a
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CONFIG_PLATFORM_8711B; PLATFORM_RTTHREAD; __IEEE_LITTLE_ENDIAN; CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; __RTTHREAD__; __RT_IPC_SOURCE__; __RT_KERNEL_SOURCE__
  ICCARM.CCOptStrategy: 0
  group amebaz_sdk
    packages/realtek_ameba-latest/sdk-ameba-v4.0b_without_NDA_GCC_V1.0.0/component/common/mbed/targets/hal/rtl8711b/: us_ticker.c timer_api.c wait_api.c analogin_api.c serial_api.c i2c_api.c spi_api.c i2s_api.c efuse_api.c rtc_api.c wdt_api.c pinmap_common.c pwmout_api.c nfc_api.c pinmap.c dma_api.c sys_api.c gpio_irq_api.c sleep.c port_api.c flash_api.c us_ticker_api.c gpio_api.c
    packages/realtek_ameba-latest/rtthread_patch/os/: rtthread_service.c
    packages/realtek_ameba-latest/sdk-ameba-v4.0b_without_NDA_GCC_V1.0.0/component/os/os_dep/: osdep_service.c
    packages/realtek_ameba-latest/rtthread_patch/realtek/common/wifi/: wifi_conf.c
    packages/realtek_ameba-latest/sdk-ameba-v4.0b_without_NDA_GCC_V1.0.0/component/common/api/wifi/rtw_wpa_supplicant/wpa_supplicant/: wifi_eap_config.c
    packages/realtek_ameba-latest/sdk-ameba-v4.0b_without_NDA_GCC_V1.0.0/component/common/api/wifi/: wifi_util.c wifi_promisc.c wifi_ind.c
    packages/realtek_ameba-latest/rtthread_patch/realtek/8711b/: app_start.c rtl8710b_startup.c
    packages/realtek_ameba-latest/sdk-ameba-v4.0b_without_NDA_GCC_V1.0.0/component/soc/realtek/8711b/cmsis/device/: system_8195a.c
    packages/realtek_ameba-latest/sdk-ameba-v4.0b_without_NDA_GCC_V1.0.0/component/soc/realtek/8711b/app/monitor/ram/: monitor.c rtl_consol.c
    packages/realtek_ameba-latest/sdk-ameba-v4.0b_without_NDA_GCC_V1.0.0/component/soc/realtek/8711b/fwlib/ram_lib/: rtl8710b_intfcfg.c rtl8710b_pinmapcfg.c
  group Applications
    applications/: smartconfig_app.c main.c
  group Compiler
    ../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
  group DeviceDrivers
    ../../components/drivers/core/: device.c
    ../../components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/wlan/: wlan_cfg.c wlan_cmd.c wlan_dev.c wlan_lwip.c wlan_mgnt.c wlan_prot.c wlan_workqueue.c
  group Drivers
    drivers/: board.c drv_uart.c
    drivers/wlan/: drv_wifi.c drv_wlan.c
  group Finsh
    ../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../src/: clock.c components.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
    ../../src/klibc/: kstdio.c kstring.c
  group libcpu
    ../../libcpu/arm/common/: div0.c showmem.c
    ../../libcpu/arm/cortex-m4/: context_iar.S cpuport.c
  group lwIP
    ../../components/net/lwip-dhcpd/: dhcp_server_raw.c
    ../../components/net/lwip/lwip-2.0.3/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../components/net/lwip/lwip-2.0.3/src/apps/ping/: ping.c
    ../../components/net/lwip/lwip-2.0.3/src/core/: def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../components/net/lwip/lwip-2.0.3/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../components/net/lwip/lwip-2.0.3/src/netif/: ethernet.c lowpan6.c
    ../../components/net/lwip/port/: ethernetif.c sys_arch.c
