# IAR project ssd1306_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMR30G18A Atmel ATSAMR30G18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __SAMR30G18A__; ARM_MATH_CM0PLUS=true; BOARD=SAMR30_XPLAINED_PRO; SPI_CALLBACK_MODE=true; SYSTICK_MODE
  ICCARM.CCIncludePath2: ../../../../../../../sam0/drivers/system/power; ../../../../../../../sam0/utils/cmsis/samr30/source; ../../../../../../../common/boards; ../../../../../../../sam0/utils/preprocessor; ../../../../../../services/delay; ../../../../../../../sam0/drivers/sercom/spi; ../../../../../../../sam0/utils; ../../../../../../../sam0/drivers/sercom; ../../../../../../../sam0/drivers/port; ../../../../../../../sam0/boards; ../../..; ../../../../../../../sam0/drivers/system/reset; ../../../../../../../common/utils; ../../../../../../../sam0/boards/samr30_xplained_pro; ../../../../../../../sam0/drivers/system/interrupt; ../../../../../../../sam0/drivers/system/power/power_sam_l; ../../../../../../../sam0/drivers/system/interrupt/system_interrupt_samr30; ../../../../../../../sam0/utils/cmsis/samr30/include; ../../../../../../services/delay/sam0; ..; ../../../../../../../sam0/drivers/system/reset/reset_sam_l; ../../../../../../../sam0/drivers/system/pinmux; ../../../../../../../sam0/drivers/system; ../../../../../../../sam0/drivers/system/clock/clock_samr30; ../../../../../../../sam0/utils/header_files; ../../../../../../../sam0/drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: ssd1306_example_flash.bin
  ILINK.IlinkOutputFile: ssd1306_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../sam0/utils/linker_scripts/samr30/iar/samr30g18a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common2/components/display/ssd1306
    ../../../: ssd1306.c ssd1306.h
  group common2/components/display/ssd1306/example
    ../../: ssd1306_example.c
  group common2/components/display/ssd1306/example/samr30_xplained_pro
    ../: conf_board.h conf_ssd1306.h conf_spi.h conf_clocks.h
  group common2/components/display/ssd1306/example/samr30_xplained_pro/iar
    ./: asf.h
  group common2/services/delay
    ../../../../../../services/delay/: delay.h
  group common2/services/delay/sam0
    ../../../../../../services/delay/sam0/: systick_counter.c systick_counter.h
  group sam0/utils
    ../../../../../../../sam0/utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/samr30/source
    ../../../../../../../sam0/utils/cmsis/samr30/source/: system_samr30.c system_samr30.h
  group sam0/utils/cmsis/samr30/source/iar
    ../../../../../../../sam0/utils/cmsis/samr30/source/iar/: startup_samr30.c
  group sam0/utils/cmsis/samr30/include
    ../../../../../../../sam0/utils/cmsis/samr30/include/: samr30g18a.h samr30e18a.h samr30.h
  group sam0/utils/cmsis/samr30/include/instance
    ../../../../../../../sam0/utils/cmsis/samr30/include/instance/: ccl.h eic.h usb.h sercom4.h sercom3.h tcc2.h oscctrl.h tc1.h nvmctrl.h tc0.h pm.h sercom5.h dmac.h mtb.h wdt.h dsu.h adc.h sercom0.h supc.h rtc.h pac.h gclk.h port.h tc4.h tcc0.h rstc.h ac.h osc32kctrl.h mclk.h sercom1.h rfctrl.h sercom2.h tcc1.h evsys.h tal.h
  group sam0/utils/cmsis/samr30/include/component
    ../../../../../../../sam0/utils/cmsis/samr30/include/component/: dmac.h rfctrl.h pm.h mtb.h dsu.h sercom.h mclk.h tc.h usb.h evsys.h ac.h supc.h tcc.h wdt.h eic.h rtc.h ccl.h osc32kctrl.h gclk.h nvmctrl.h adc.h pac.h tal.h oscctrl.h port.h rstc.h
  group sam0/utils/cmsis/samr30/include/pio
    ../../../../../../../sam0/utils/cmsis/samr30/include/pio/: samr30g18a.h samr30e18a.h
  group sam0/utils/header_files
    ../../../../../../../sam0/utils/header_files/: io.h
  group sam0/utils/preprocessor
    ../../../../../../../sam0/utils/preprocessor/: mrepeat.h mrecursion.h tpaste.h preprocessor.h stringz.h
  group sam0/drivers/system
    ../../../../../../../sam0/drivers/system/: system.c system.h
  group sam0/drivers/system/interrupt
    ../../../../../../../sam0/drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samr30
    ../../../../../../../sam0/drivers/system/interrupt/system_interrupt_samr30/: system_interrupt_features.h
  group sam0/drivers/system/pinmux
    ../../../../../../../sam0/drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../../../sam0/drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/clock
    ../../../../../../../sam0/drivers/system/clock/: clock.h gclk.h
  group sam0/drivers/system/clock/clock_samr30
    ../../../../../../../sam0/drivers/system/clock/clock_samr30/: clock.c gclk.c clock_config_check.h clock_feature.h
  group sam0/drivers/system/power/power_sam_l
    ../../../../../../../sam0/drivers/system/power/power_sam_l/: power.h
  group sam0/drivers/system/reset/reset_sam_l
    ../../../../../../../sam0/drivers/system/reset/reset_sam_l/: reset.h
  group sam0/drivers/port
    ../../../../../../../sam0/drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../../../sam0/drivers/port/quick_start/: qs_port_basic.h
  group sam0/drivers/sercom
    ../../../../../../../sam0/drivers/sercom/: sercom.c sercom_interrupt.c sercom_pinout.h sercom.h sercom_interrupt.h
  group sam0/drivers/sercom/spi
    ../../../../../../../sam0/drivers/sercom/spi/: spi_interrupt.c spi.c spi.h spi_interrupt.h
  group sam0/drivers/sercom/spi/quick_start_slave
    ../../../../../../../sam0/drivers/sercom/spi/quick_start_slave/: qs_spi_slave_basic.h
  group sam0/drivers/sercom/spi/quick_start_slave_callback
    ../../../../../../../sam0/drivers/sercom/spi/quick_start_slave_callback/: qs_spi_slave_callback.h
  group sam0/drivers/sercom/spi/quick_start_dma
    ../../../../../../../sam0/drivers/sercom/spi/quick_start_dma/: qs_spi_dma_use.h
  group sam0/drivers/sercom/spi/quick_start_master
    ../../../../../../../sam0/drivers/sercom/spi/quick_start_master/: qs_spi_master_basic.h
  group sam0/drivers/sercom/spi/quick_start_master_callback
    ../../../../../../../sam0/drivers/sercom/spi/quick_start_master_callback/: qs_spi_master_callback.h
  group sam0/boards/samr30_xplained_pro
    ../../../../../../../sam0/boards/samr30_xplained_pro/: board_init.c samr30_xplained_pro.h
  group common/utils
    ../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../../common/boards/: board.h
