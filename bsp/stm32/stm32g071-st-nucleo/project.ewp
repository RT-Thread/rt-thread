# IAR project project.ewp, settings and files
configuration rt-thread (ARM, debug)
  General.OGChipSelectEditMenu: STM32G071RB ST STM32G071RB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: STM32G071xx; __RTTHREAD__; USE_HAL_DRIVER
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\components\libc\compilers\common\nogcc; ..\..\..\libcpu\arm\cortex-m0; ..\..\..\components\finsh; ..\..\..\libcpu\arm\common; ..\..\..\components\drivers\include; ..\libraries\STM32G0xx_HAL\STM32G0xx_HAL_Driver\Inc; ..\..\..\examples\utest\testcases\kernel; .; applications; ..\libraries\HAL_Drivers\config; ..\libraries\STM32G0xx_HAL\CMSIS\Device\ST\STM32G0xx\Include; board; ..\..\..\components\libc\compilers\common; ..\libraries\STM32G0xx_HAL\CMSIS\Include; board\CubeMX_Config\Inc; ..\..\..\include; ..\libraries\HAL_Drivers
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../../rtthread.bin
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: main.c
  group CPU
    ../../../libcpu/arm/common/: div0.c showmem.c backtrace.c
    ../../../libcpu/arm/cortex-m0/: cpuport.c context_iar.S
  group DeviceDrivers
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/src/: ringblk_buf.c dataqueue.c waitqueue.c ringbuffer.c pipe.c workqueue.c completion.c
  group Drivers
    board/CubeMX_Config/Src/: stm32g0xx_hal_msp.c
    ../libraries/STM32G0xx_HAL/CMSIS/Device/ST/STM32G0xx/Source/Templates/iar/: startup_stm32g071xx.s
    board/: board.c
    ../libraries/HAL_Drivers/: drv_gpio.c drv_usart.c drv_common.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c cmd.c
  group Kernel
    ../../../src/: mempool.c timer.c device.c idle.c kservice.c ipc.c clock.c thread.c scheduler.c object.c irq.c mem.c components.c
  group libc
    ../../../components/libc/compilers/common/: time.c
  group Libraries
    ../libraries/STM32G0xx_HAL/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal_cec.c stm32g0xx_hal_pwr.c stm32g0xx_hal_dma_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_rcc_ex.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_pwr_ex.c stm32g0xx_ll_usart.c stm32g0xx_hal_usart_ex.c stm32g0xx_hal_cortex.c stm32g0xx_hal.c stm32g0xx_hal_rcc.c stm32g0xx_hal_dma.c stm32g0xx_hal_uart.c stm32g0xx_hal_uart_ex.c
    ../libraries/STM32G0xx_HAL/CMSIS/Device/ST/STM32G0xx/Source/Templates/: system_stm32g0xx.c
