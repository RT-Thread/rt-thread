# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060020::V5.06 (build 20)::ARMCC)
  device: HC32L196JCTA HDSC
  pack: HDSC.HC32L19X.1.0.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: rtthread +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: RT_USING_LIBC, __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND, __STDC_LIMIT_MACROS, RT_USING_ARMLIBC
  c include: ..\..\include;..\..\components\libc\compilers\common\extension;..\..\libcpu\arm\common;..\..\components\libc\posix\ipc;..\..\components\drivers\phy;..\..\components\net\utest;..\..\components\libc\posix\io\epoll;..\..\components\drivers\include;board;..\..\libcpu\arm\cortex-m0;..\..\components\libc\posix\io\eventfd;..\..\components\libc\posix\io\poll;..\..\components\drivers\include;..\..\components\drivers\include;.;..\..\components\drivers\include;drivers;..\..\components\drivers\include;applications;..\..\components\drivers\include;..\..\components\drivers\smp_call;..\..\components\libc\compilers\common\include;..\..\components\finsh;libraries\CMSIS\Device\HDSC\HC32L196\Include;libraries\HC32L196_StdPeriph_Driver\inc;..\..\components\libc\compilers\common\extension\fcntl\octal;libraries\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group CPU
    ../../libcpu/arm/common/: div0.c showmem.c
    ../../libcpu/arm/cortex-m0/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../components/drivers/core/: device.c
    ../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../components/drivers/pin/: dev_pin.c
    ../../components/drivers/serial/: dev_serial.c
  group Drivers
    board/: board.c board_config.c
    drivers/: drv_gpio.c drv_usart.c
  group Finsh
    ../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group HC32_StdPeriph
    libraries/CMSIS/Device/HDSC/HC32L196/Source/: system_hc32l19x.c interrupts_hc32l19x.c
    libraries/HC32L196_StdPeriph_Driver/src/: hc32l196_ddl.c hc32l196_gpio.c hc32l196_sysctrl.c hc32l196_flash.c hc32l196_uart.c
    libraries/CMSIS/Device/HDSC/HC32L196/Source/ARM/: startup_hc32l19x.s
  group Kernel
    ../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group Libc
    ../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
