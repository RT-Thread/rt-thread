# Keil uVision project project.uvprojx, settings and files
target rt-thread_gd32f30x (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F303ZE GigaDevice
  pack: GigaDevice.GD32F30x_DFP.1.0.1
  cpu: IRAM(0x20000000-0x2000FFFF)IROM(0x08000000-0x0807FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4")
  output: rtthread-gd32f30x
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: GD32F30X_HD, __STDC_LIMIT_MACROS, RT_USING_ARMLIBC, USE_STDPERIPH_DRIVER, RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND, __RTTHREAD__
  c include: ..\..\components\dfs\filesystems\devfs;..\..\components\libc\compilers\common\extension;..\..\components\drivers\include;..\..\include;Libraries\CMSIS\GD\GD32F30x\Include;..\..\components\drivers\include;..\..\components\drivers\spi;..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\components\libc\posix\io\stdio;Libraries\CMSIS;..\..\components\dfs\include;..\..\components\dfs\filesystems\elmfat;applications;drivers;Libraries\GD32F30x_standard_peripheral\Include;..\..\components\drivers\include;..\..\libcpu\arm\cortex-m4;..\..\components\drivers\include;..\..\libcpu\arm\common;.;..\..\components\libc\posix\ipc;..\..\components\drivers\include;..\..\components\libc\posix\io\poll;..\..\components\libc\compilers\common\include;..\..\components\finsh;..\..\components\drivers\spi\sfud\inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Applications
    applications/: main.c
  group Compiler
    ../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../components/libc/compilers/common/: cctype.c cstdio.c cstdlib.c cstring.c ctime.c cwchar.c
  group CPU
    ../../libcpu/arm/common/: div0.c showmem.c
    ../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../components/drivers/i2c/: i2c_core.c i2c_dev.c
    ../../components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../components/drivers/misc/: pin.c
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/spi/sfud/src/: sfud.c
    ../../components/drivers/spi/: spi_core.c spi_dev.c spi_flash_sfud.c
  group Drivers
    drivers/: drv_gpio.c drv_spi.c drv_i2c.c drv_spi_flash.c drv_usart.c board.c
  group Filesystem
    ../../components/dfs/filesystems/devfs/: devfs.c
    ../../components/dfs/filesystems/elmfat/: dfs_elm.c ff.c ffunicode.c
    ../../components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    ../../components/finsh/: shell.c msh.c msh_parse.c cmd.c msh_file.c
  group Kernel
    ../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_up.c thread.c timer.c
  group Libraries
    Libraries/GD32F30x_standard_peripheral/Source/: gd32f30x_gpio.c gd32f30x_dbg.c gd32f30x_misc.c gd32f30x_exmc.c gd32f30x_sdio.c gd32f30x_adc.c gd32f30x_pmu.c gd32f30x_ctc.c gd32f30x_fmc.c gd32f30x_crc.c gd32f30x_spi.c gd32f30x_fwdgt.c gd32f30x_bkp.c gd32f30x_enet.c gd32f30x_i2c.c gd32f30x_wwdgt.c gd32f30x_dac.c gd32f30x_usart.c gd32f30x_timer.c gd32f30x_can.c gd32f30x_rcu.c gd32f30x_exti.c gd32f30x_rtc.c gd32f30x_dma.c
    Libraries/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
    Libraries/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_hd.s
software components: CMSIS:CORE 5.0.1
