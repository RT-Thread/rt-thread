# Keil uVision project project.uvprojx, settings and files
target Target_1 (6190000::V6.19::ARMCLANG)
  device: R7KA8P1KF:CPU0 Renesas
  pack: Renesas.RA_DFP.6.5.1
  cpu: CPUTYPE("Cortex-M85") DSP TZ MVE(FP) FPU3(DFPU) PACBTI CLOCK(12000000) ELITTLE
  output: template +hex
  AfterMake: cmd /c ""$Prasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --gensmartbundle --compiler ARMv6 --devicefamily ra "$Pconfiguration.xml" "$L%L" 2> "$PObjects\rasc_stderr.out""
  c flags: v6Lang=3 v6LangP=6
  c define: _RA_CORE=CPU0, __RTTHREAD__, _RENESAS_RA_, RT_USING_LIBC, RT_USING_ARMLIBC, __CLK_TCK=RT_TICK_PER_SECOND, __STDC_LIMIT_MACROS, _RA_ORDINAL=1
  c include: ..\..\..\..\components\drivers\include;ra_cfg\fsp_cfg\bsp;..\..\..\..\components\drivers\include;..\..\..\..\components\drivers\include;..\..\..\..\libcpu\arm\cortex-m85;..\..\..\..\components\libc\compilers\common\include;..\..\..\..\components\libc\posix\io\eventfd;ra\fsp\src\rm_ethosu;..\..\..\..\components\net\utest;..\..\..\..\include;..\..\..\..\components\libc\posix\io\poll;ra\tes\dave2d\inc;..\..\..\..\components\drivers\phy;ra_gen;..\..\..\..\components\libc\compilers\common\extension\fcntl\octal;board\ports;ra\npu\ethos-u-core-driver\include;board;..\..\..\..\components\drivers\include;..\..\libraries\HAL_Drivers\drivers\config;ra\fsp\inc\api;.;..\..\..\..\components\libc\compilers\common\extension;..\..\..\..\components\drivers\include;ra\fsp\inc\instances;..\..\libraries\HAL_Drivers;ra_cfg\fsp_cfg;..\..\..\..\libcpu\arm\common;..\..\..\..\components\finsh;..\..\libraries\HAL_Drivers\drivers;..\..\..\..\components\drivers\include;ra\fsp\src\r_mipi_csi;..\..\..\..\components\drivers\include;..\..\..\..\components\libc\posix\io\epoll;..\..\..\..\components\drivers\smp_call;ra\fsp\inc;..\..\..\..\components\libc\posix\ipc;ra\fsp\src\r_vin;ra\arm\CMSIS_6\CMSIS\Core\Include
  scatter file: .\script\fsp.scat
  link misc: --entry=Reset_Handler --no_startup
  group Applications
    src/: hal_entry.c
  group CPU
    ../../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../../libcpu/arm/cortex-m85/: context_gcc.S cpuport.c
  group DeviceDrivers
    ../../../../components/drivers/core/: device.c
    ../../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../components/drivers/mtd/: mtd_nor.c
    ../../../../components/drivers/pin/: dev_pin.c
    ../../../../components/drivers/serial/: dev_serial_v2.c
  group Drivers
    ../../libraries/HAL_Drivers/drivers/: drv_gpio.c drv_usart_v2.c
    ../../libraries/HAL_Drivers/: drv_common.c
    board/: ra8_it.c
  group Finsh
    ../../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group Libc
    ../../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../../src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
  group RA
    ra/fsp/src/bsp/mcu/all/: bsp_clocks.c bsp_common.c bsp_delay.c bsp_group_irq.c bsp_guard.c bsp_io.c bsp_ipc.c bsp_irq.c bsp_macl.c bsp_ospi_b.c bsp_register_protection.c bsp_sbrk.c bsp_sdram.c bsp_security.c
    ra/fsp/src/bsp/mcu/ra8p1/: bsp_linker.c
    ra/fsp/src/bsp/cmsis/Device/RENESAS/Source/: system.c startup.c
    ra/fsp/src/r_adc_b/: r_adc_b.c
    ra/fsp/src/r_canfd/: r_canfd.c
    ra/fsp/src/r_dmac/: r_dmac.c
    ra/fsp/src/r_gpt/: r_gpt.c
    ra/fsp/src/r_iic_master/: r_iic_master.c
    ra/fsp/src/r_ioport/: r_ioport.c
    ra/fsp/src/r_layer3_switch/: r_layer3_switch.c
    ra/fsp/src/r_ospi_b/: r_ospi_b.c
    ra/fsp/src/r_rmac/: r_rmac.c
    ra/fsp/src/r_rmac_phy/: r_rmac_phy.c
    ra/fsp/src/r_rtc/: r_rtc.c
    ra/fsp/src/r_sci_b_uart/: r_sci_b_uart.c
    ra/fsp/src/r_sdhi/: r_sdhi.c
    ra/fsp/src/r_spi_b/: r_spi_b.c
  group RA_gen
    ra_gen/: common_data.c hal_data.c main.c pin_data.c vector_data.c
software components: Flex Software:RA Configuration 1.0.0
