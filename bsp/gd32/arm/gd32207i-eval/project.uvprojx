# Keil uVision project project.uvprojx, settings and files
target rt-thread (ARM-ADS)
  device: GD32F207IK GigaDevice
  pack: GigaDevice.GD32F20x_DFP.2.2.2
  cpu: IRAM(0x20000000,0x040000) IROM(0x08000000,0x0300000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=4 uC99=1 v6Lang=1 v6LangP=1
  c define: RT_USING_ARMLIBC, GD32F20X_CL, __RTTHREAD__, __STDC_LIMIT_MACROS, USE_STDPERIPH_DRIVER, RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND
  c include: ..\..\..\..\components\drivers\include;..\..\..\..\components\net\utest;..\..\..\..\libcpu\arm\cortex-m3;packages\gd32-arm-cmsis-latest\GD32F20x;..\..\..\..\components\drivers\include;..\..\..\..\components\finsh;applications;..\..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\..\components\libc\compilers\common\extension;..\..\..\..\components\drivers\include;..\..\..\..\components\libc\posix\io\epoll;.;..\libraries\gd32_drivers;..\..\..\..\components\libc\compilers\common\include;packages\gd32-arm-cmsis-latest\GD32F20x\GD\GD32F20x\Include;..\..\..\..\components\drivers\phy;board;packages\gd32-arm-series-latest\GD32F20x\GD32F20x_standard_peripheral\Include;..\..\..\..\include;..\..\..\..\libcpu\arm\common;..\libraries\gd32_drivers\config;..\..\..\..\components\drivers\include;..\..\..\..\components\drivers\smp_call;..\..\..\..\components\drivers\include;..\..\..\..\components\libc\posix\io\eventfd;..\..\..\..\components\libc\posix\ipc;..\..\..\..\components\libc\posix\io\poll
  memory RVCT4: ROM 0x8000000 size 0x300000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Applications
    applications/: main.c
  group Compiler
    ../../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../../components/drivers/core/: device.c
    ../../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../components/drivers/pin/: dev_pin.c
    ../../../../components/drivers/serial/: dev_serial.c
  group Drivers
    board/: board.c
    ../libraries/gd32_drivers/: drv_gpio.c drv_usart.c
  group Finsh
    ../../../../components/finsh/: cmd.c msh.c shell.c msh_parse.c
  group Kernel
    ../../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    ../../../../src/klibc/: rt_vsscanf.c rt_vsnprintf_tiny.c kstdio.c kstring.c kerrno.c
  group libcpu
    ../../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../../libcpu/arm/cortex-m3/: context_rvds.S cpuport.c
  group Libraries
    packages/gd32-arm-cmsis-latest/GD32F20x/GD/GD32F20x/Source/ARM/: startup_gd32f20x_cl.s
    packages/gd32-arm-cmsis-latest/GD32F20x/GD/GD32F20x/Source/: system_gd32f20x.c
    packages/gd32-arm-series-latest/GD32F20x/GD32F20x_standard_peripheral/Source/: gd32f20x_exti.c gd32f20x_gpio.c gd32f20x_misc.c gd32f20x_rcu.c gd32f20x_usart.c
software components: CMSIS:CORE 5.4.0
