# Keil uVision project project.uvprojx, settings and files
target rtthread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MIMXRT1061CVL5A NXP
  pack: NXP.MIMXRT1061_DFP.16.0.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x00000000,0x020000) IROM(0x00200000,0x020000) XRAM(0x20280000,0x040000) XRAM2(0x20200000,0x080000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: SKIP_SYSCLK_INIT, RT_USING_LIBC, __RTTHREAD__, CPU_MIMXRT1061CVL5A, EVK_MCIMXRM, __STDC_LIMIT_MACROS, XIP_EXTERNAL_FLASH=1, __CLK_TCK=RT_TICK_PER_SECOND, FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1, RT_USING_ARMLIBC
  c misc: --library_interface=armcc --library_type=standardlib --diag_suppress=66,1296,186
  c include: ..\..\..\..\..\components\drivers\include;..\libraries\MIMXRT1061\CMSIS\Include;..\libraries\drivers;..\..\..\..\..\components\libc\compilers\common\include;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\libc\compilers\common\extension;..\..\..\..\..\components\drivers\include;.;applications;..\libraries\MIMXRT1061\MIMXRT1061;..\libraries\MIMXRT1061\MIMXRT1061\drivers;..\..\..\..\..\components\libc\posix\io\epoll;..\..\..\..\..\components\drivers\include;board;board\ports;..\..\..\..\..\components\finsh;..\..\..\..\..\components\libc\posix\io\poll;..\..\..\..\..\components\drivers\smp_call;board\MCUX_Config;..\..\..\..\..\include;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\libc\posix\ipc;..\..\..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\..\..\components\libc\posix\io\eventfd;..\..\..\..\..\libcpu\arm\common;..\..\..\..\..\libcpu\arm\cortex-m7;..\..\..\..\..\components\drivers\phy
  memory RVCT4: ROM 0x200000 size 0x20000
  memory RVCT6: ROM 0x20280000 size 0x40000
  memory RVCT7: ROM 0x20200000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group Compiler
    ../../../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../../../components/drivers/core/: device.c
    ../../../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../../components/drivers/pin/: dev_pin.c
    ../../../../../components/drivers/serial/: dev_serial.c
  group Drivers
    board/MCUX_Config/: clock_config.c pin_mux.c
    board/: board.c
    ../libraries/drivers/: drv_common.c drv_gpio.c drv_uart.c
  group Finsh
    ../../../../../components/finsh/: cmd.c msh.c msh_parse.c shell.c
  group Kernel
    ../../../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    ../../../../../src/klibc/: kerrno.c kstring.c kstdio.c rt_vsnprintf_tiny.c rt_vsscanf.c
  group libcpu
    ../../../../../libcpu/arm/common/: div0.c showmem.c
    ../../../../../libcpu/arm/cortex-m7/: context_rvds.S cpu_cache.c cpuport.c
  group Libraries
    ../libraries/MIMXRT1061/MIMXRT1061/drivers/: fsl_clock.c fsl_lpuart.c generic_list.c fsl_os_abstraction_rtthread.c fsl_common.c fsl_xbara.c fsl_cache.c fsl_xbarb.c fsl_gpio.c
    ../libraries/MIMXRT1061/MIMXRT1061/: system_MIMXRT1061.c
    ../libraries/MIMXRT1061/MIMXRT1061/arm/: startup_MIMXRT1061.s
