# IAR project project.ewp, settings and files
configuration rt-thread (ARM, debug)
  General.OGChipSelectEditMenu: STM32L552ZE ST STM32L552ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: RT_USING_DLIBC; STM32L552xx; __RTTHREAD__; USE_HAL_DRIVER
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\libraries\STM32L5xx_HAL\CMSIS\Include; ..\libraries\HAL_Drivers; ..\..\..\libcpu\arm\common; ..\..\..\components\libc\posix\ipc; ..\libraries\STM32L5xx_HAL\STM32L5xx_HAL_Driver\Inc; ..\..\..\components\drivers\include; ..\..\..\examples\utest\testcases\kernel; .; ..\..\..\libcpu\arm\cortex-m33; applications; ..\..\..\components\finsh; ..\libraries\HAL_Drivers\config; board; ..\..\..\components\libc\compilers\common; ..\..\..\components\libc\posix\io\poll; board\CubeMX_Config\Inc; ..\..\..\include; ..\..\..\components\libc\compilers\common\nogcc; ..\libraries\STM32L5xx_HAL\CMSIS\Device\ST\STM32L5xx\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../../rtthread.bin
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: main.c
  group Compiler
    ../../../components/libc/compilers/common/: time.c stdlib.c
    ../../../components/libc/compilers/dlib/: syscall_close.c syscalls.c syscall_lseek.c syscall_mem.c syscall_remove.c syscall_open.c syscall_write.c environ.c syscall_read.c
  group CPU
    ../../../libcpu/arm/common/: showmem.c div0.c backtrace.c
    ../../../libcpu/arm/cortex-m33/: cpuport.c context_iar.S syscall_iar.S trustzone.c
  group DeviceDrivers
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/src/: dataqueue.c waitqueue.c pipe.c ringblk_buf.c completion.c workqueue.c ringbuffer.c
  group Drivers
    board/CubeMX_Config/Src/: stm32l5xx_hal_msp.c
    ../libraries/STM32L5xx_HAL/CMSIS/Device/ST/STM32L5xx/Source/Templates/iar/: startup_stm32l552xx.s
    board/: board.c
    ../libraries/HAL_Drivers/: drv_gpio.c drv_usart.c drv_common.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c cmd.c
  group Kernel
    ../../../src/: mem.c idle.c thread.c kservice.c device.c scheduler.c ipc.c timer.c components.c object.c irq.c clock.c mempool.c
  group Libraries
    ../libraries/STM32L5xx_HAL/STM32L5xx_HAL_Driver/Src/: stm32l5xx_hal_pwr.c stm32l5xx_hal_dma_ex.c stm32l5xx_hal_gpio.c stm32l5xx_hal_rcc_ex.c stm32l5xx_hal_usart.c stm32l5xx_hal_uart_ex.c stm32l5xx_hal_pwr_ex.c stm32l5xx_hal_cryp.c stm32l5xx_hal_usart_ex.c stm32l5xx_hal_exti.c stm32l5xx_hal_cortex.c stm32l5xx_hal.c stm32l5xx_hal_rcc.c stm32l5xx_hal_dma.c stm32l5xx_hal_uart.c stm32l5xx_hal_comp.c stm32l5xx_hal_rng.c stm32l5xx_hal_crc.c stm32l5xx_hal_crc_ex.c stm32l5xx_hal_cryp_ex.c
    ../libraries/STM32L5xx_HAL/CMSIS/Device/ST/STM32L5xx/Source/Templates/: system_stm32l5xx.c
