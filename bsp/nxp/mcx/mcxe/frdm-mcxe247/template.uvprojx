# Keil uVision project template.uvprojx, settings and files
target rtthread-frdm-mcxe247 (6230000::V6.23::ARMCLANG)
  device: MCXE247VLQ NXP
  pack: NXP.MCXE247_DFP.25.06.00
  cpu: IRAM(0x14000000,0x1000) IRAM2(0x1ffe0000,0x020000) IROM(0x10000000,0x080000) IROM2(0x00000000,0x180000) XRAM(0x20000000,0x01f000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rtthread
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=3
  c define: CPU_MCXE247VLQ, ARM_MATH_CM4,  RT_USING_ARM_LIBC
  c misc: --target=arm-arm-none-eabi
  asm misc: -x assembler-with-cpp
  memory RVCT4: ROM 0x10000000 size 0x80000
  memory RVCT5: ROM 0x0 size 0x180000
  memory RVCT6: RAM 0x20000000 size 0x1f000
  memory RVCT9: RAM 0x14000000 size 0x1000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: .\board\linker_scripts\MCXE247_flash.scf
  link misc: --keep *.o(.rti_fn.*)   --keep *.o(FSymTab) --keep *.o(VSymTab)
