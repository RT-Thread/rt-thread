# Keil uVision project project.uvprojx, settings and files
target ACM32F4XX (6150000::V6.15::ARMCLANG)
  device: ARMCM33_DSP_FP ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x20200000,0x00020000) IROM(0x00000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ESEL ELITTLE
  output: ACM32F4XX +hex
  AfterMake: fromelf.exe --bin --output ./build/ACM32F4.bin ./build/ACM32F4.axf
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3
  c define: RT_USING_ARM_LIBC, __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND
  c include: libraries\HAL_Driver\Inc;libraries\Device;libraries\CMSIS;applications;.;..\..\libcpu\arm\common;..\..\libcpu\arm\cortex-m33;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\drivers\include;drivers;..\..\components\finsh;.;..\..\include;..\..\components\libc\compilers\armlibc;..\..\components\libc\compilers\common;..\..\components\libc\compilers\common\nogcc;..\..\examples\utest\testcases\kernel
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x20200000 size 0x20000
  group ACM32_HAL
    libraries/HAL_Driver/Src/: HAL_UART.c HAL_EXTI.c HAL_DMA.c HAL_GPIO.c HAL_EFlash.c HAL_EFlash_EX.lib
    libraries/Device/: Startup_ACM32F4.s System_ACM32F4.c System_Accelerate.lib
  group Applications
    applications/: main.c
  group CPU
    ../../libcpu/arm/common/: backtrace.c showmem.c div0.c
    ../../libcpu/arm/cortex-m33/: syscall_rvds.S context_rvds.S trustzone.c cpuport.c
  group DeviceDrivers
    ../../components/drivers/misc/: pin.c
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/src/: pipe.c ringbuffer.c ringblk_buf.c waitqueue.c dataqueue.c workqueue.c completion.c
  group Drivers
    drivers/: drv_gpio.c board.c drv_uart.c
  group Finsh
    ../../components/finsh/: shell.c msh.c cmd.c
  group Kernel
    ../../src/: mem.c idle.c irq.c scheduler.c mempool.c ipc.c clock.c device.c object.c kservice.c thread.c timer.c components.c
  group libc
    ../../components/libc/compilers/armlibc/: libc.c syscalls.c mem_std.c
    ../../components/libc/compilers/common/: stdlib.c time.c
