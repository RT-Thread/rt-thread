# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: STM32F10xxE ST STM32F10xxE
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_HD
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: .; Libraries\STM32F10x_StdPeriph_Driver\inc; Libraries\CMSIS\CM3\CoreSupport; Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\include; ..\..\libcpu\arm\stm32; ..\..\components\finsh; ..\..\components\dfs; ..\..\components\dfs\include; ..\..\components\dfs\filesystems\efsl\src\include; ..\..\components\dfs\filesystems\efsl\src\base\include; ..\..\components\dfs\filesystems\efsl\src\fs\vfat\include; ..\..\components\net\lwip\src; ..\..\components\net\lwip\src\include; ..\..\components\net\lwip\src\arch\include; ..\..\components\net\lwip\src\include\ipv4
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: project.srec
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; USE_STDPERIPH_DRIVER; STM32F10X_HD
  ICCARM.CCIncludePath2: .; Libraries\STM32F10x_StdPeriph_Driver\inc; Libraries\CMSIS\Core\CM3; ..\..\include; ..\..\libcpu\arm\stm32; ..\..\finsh; ..\..\filesystem\dfs; ..\..\filesystem\dfs\include; ..\..\filesystem\dfs\filesystems\efsl\src\include; ..\..\filesystem\dfs\filesystems\efsl\src\base\include; ..\..\filesystem\dfs\filesystems\efsl\src\fs\vfat\include; ..\..\net\lwip\src; ..\..\net\lwip\src\include; ..\..\net\lwip\src\arch\include; ..\..\net\lwip\src\include\ipv4
  ICCARM.CCOptLevel: 3
  group CMSIS
    Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ./: system_stm32f10x.c
  group Filesystem
    ../../components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
    ../../components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
  group finsh
    ../../components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c shell.c symbol.c
  group Kernel
    ../../src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c slab.c thread.c timer.c
  group LwIP
    ../../components/net/lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../components/net/lwip/src/core/snmp/: asn1_dec.c asn1_enc.c mib2.c mib_structs.c msg_in.c msg_out.c
    ../../components/net/lwip/src/netif/ppp/: auth.c chap.c chpms.c fsm.c ipcp.c lcp.c magic.c md5.c pap.c ppp.c ppp_oe.c randm.c vj.c
    ../../components/net/lwip/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../components/net/lwip/src/core/: dhcp.c dns.c init.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
    ../../components/net/lwip/src/netif/: etharp.c ethernetif.c loopif.c slipif.c
    ../../components/net/lwip/src/arch/: sys_arch.c sys_arch_init.c
  group Startup
    ./: application.c board.c board.h dm9000a.c enc28j60.c led.c msd.c rtc.c rtconfig.h sdcard.c startup.c stm32f10x_it.c usart.c
  group StdPeriph_Driver
    Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group STM32
    ../../libcpu/arm/stm32/: context_iar.S cpu.c fault.c fault_iar.S interrupt.c serial.c stack.c start_iar.s
