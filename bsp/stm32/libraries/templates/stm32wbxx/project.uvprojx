# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32WB55RGVx STMicroelectronics
  pack: Keil.STM32WBxx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00040000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_HAL_DRIVER, RT_USING_ARM_LIBC, STM32WB55xx
  c include: .;applications;..\..\..\libcpu\arm\common;..\..\..\libcpu\arm\cortex-m4;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;board;board\CubeMX_Config\Inc;board\ports;..\libraries\HAL_Drivers;..\libraries\HAL_Drivers\config;..\..\..\components\finsh;.;..\..\..\include;..\..\..\components\libc\compilers\armlibc;..\..\..\components\libc\compilers\common;..\libraries\STM32WBxx_HAL\STM32WBxx_HAL_Driver\Inc;..\libraries\STM32WBxx_HAL\CMSIS\Device\ST\STM32WBxx\Include;..\libraries\STM32WBxx_HAL\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group cpu
    ../../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
  group DeviceDrivers
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
  group Drivers
    board/: board.c
    board/CubeMX_Config/Src/: stm32wbxx_hal_msp.c
    ../libraries/STM32WBxx_HAL/CMSIS/Device/ST/STM32WBxx/Source/Templates/arm/: startup_stm32wb55xx_cm4.s
    ../libraries/HAL_Drivers/: drv_gpio.c drv_usart.c drv_common.c
  group finsh
    ../../../components/finsh/: shell.c cmd.c msh.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_var.c finsh_vm.c finsh_token.c
  group Kernel
    ../../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group libc
    ../../../components/libc/compilers/armlibc/: libc.c mem_std.c stubs.c
    ../../../components/libc/compilers/common/: time.c
  group STM32_HAL
    ../libraries/STM32WBxx_HAL/CMSIS/Device/ST/STM32WBxx/Source/Templates/: system_stm32wbxx.c
    ../libraries/STM32WBxx_HAL/STM32WBxx_HAL_Driver/Src/: STM32wbxx_hal.c STM32wbxx_hal_comp.c STM32wbxx_hal_cortex.c STM32wbxx_hal_crc.c STM32wbxx_hal_crc_ex.c STM32wbxx_hal_cryp.c STM32wbxx_hal_cryp_ex.c STM32wbxx_hal_dma.c STM32wbxx_hal_dma_ex.c STM32wbxx_hal_exti.c STM32wbxx_hal_pwr.c STM32wbxx_hal_pwr_ex.c STM32wbxx_hal_rcc.c STM32wbxx_hal_rcc_ex.c STM32wbxx_hal_rng.c STM32wbxx_hal_gpio.c STM32wbxx_hal_uart.c STM32wbxx_hal_uart_ex.c STM32wbxx_hal_usart.c STM32wbxx_hal_usart_ex.c
