# Keil uVision project project.uvprojx, settings and files
target rtthread-frdm-mcxa156 (6180000::V6.18::ARMCLANG)
  device: MCXA156VLL NXP
  pack: NXP.MCXA156_DFP.19.0.0
  cpu: IRAM(0x20000000,0x01e000) IRAM2(0x04000000,0x3000) IROM(0x03000000,0x2000) IROM2(0x00000000,0x100000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ELITTLE
  output: rtthread
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=3
  c define: __RTTHREAD__, RT_USING_ARMLIBC, DEBUG, __STDC_LIMIT_MACROS, CPU_MCXA156VLL, RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND
  c misc: --target=arm-arm-none-eabi
  c include: ..\..\..\..\..\components\libc\compilers\common\extension;..\..\..\..\..\components\libc\compilers\common\include;..\libraries\MCXA156\MCXA156;..\..\..\..\..\components\libc\posix\io\epoll;..\libraries\MCXA156\MCXA156\drivers;..\..\..\..\..\components\libc\posix\ipc;..\..\..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\utilities\ulog;..\libraries\MCXA156\middleware\sdmmc\inc;..\..\..\..\..\components\drivers\include;board\MCUX_Config\board;..\..\..\..\..\libcpu\arm\common;..\..\..\..\..\libcpu\arm\cortex-m33;..\..\..\..\..\components\finsh;..\libraries\CMSIS\Core\Include;board;..\libraries\drivers\config;..\libraries\MCXA156\middleware\sdmmc\port;..\..\..\..\..\components\libc\posix\io\eventfd;..\..\..\..\..\components\drivers\include;.;..\..\..\..\..\components\drivers\include;..\libraries\drivers;..\..\..\..\..\components\libc\posix\io\poll;applications;..\libraries\MCXA156\components\codec;..\..\..\..\..\components\drivers\include;..\..\..\..\..\include
  asm misc: -x assembler-with-cpp
  memory RVCT4: ROM 0x3000000 size 0x2000
  memory RVCT5: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1e000
  memory RVCT10: RAM 0x4000000 size 0x3000
  scatter file: .\board\linker_scripts\MCXA156_flash.scf
  group Applications
    applications/: main.c
  group Compiler
    ../../../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../../../components/drivers/core/: device.c
    ../../../../../components/drivers/clock_time/: clock_timer.c
    ../../../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../../components/drivers/pin/: pin.c
    ../../../../../components/drivers/serial/: serial.c
  group Drivers
    board/MCUX_Config/board/: clock_config.c pin_mux.c
    board/: board.c
    ../libraries/drivers/: drv_pin.c drv_uart.c
  group Finsh
    ../../../../../components/finsh/: cmd.c msh.c shell.c msh_parse.c
  group Kernel
    ../../../../../src/: clock.c components.c cpu_up.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
    ../../../../../src/klibc/: kstdio.c kstring.c
  group libcpu
    ../../../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../../../libcpu/arm/cortex-m33/: context_rvds.S cpuport.c syscall_rvds.S trustzone.c
  group Libraries
    ../libraries/MCXA156/MCXA156/drivers/: fsl_lpadc.c fsl_gpio.c fsl_crc.c fsl_edma.c fsl_ostimer.c fsl_vbat.c fsl_common.c fsl_edma_soc.c fsl_lpuart_edma.c fsl_cmc.c fsl_eim.c fsl_i3c.c fsl_freqme.c fsl_lpi2c.c fsl_reset.c fsl_eqdc.c fsl_waketimer.c fsl_glikey.c fsl_inputmux.c fsl_pwm.c fsl_erm.c fsl_spc.c fsl_i3c_edma.c fsl_lpuart.c fsl_lpi2c_edma.c fsl_utick.c fsl_ctimer.c fsl_common_arm.c fsl_lptmr.c fsl_wuu.c fsl_wwdt.c fsl_aoi.c fsl_lpcmp.c fsl_clock.c
    ../libraries/MCXA156/MCXA156/arm/: startup_MCXA156.s
    ../libraries/MCXA156/MCXA156/: system_MCXA156.c
  group Utilities
    ../../../../../components/utilities/ulog/backend/: console_be.c
    ../../../../../components/utilities/ulog/: ulog.c
