# Keil uVision project project.uvprojx, settings and files
target rtthread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MIMXRT1064DVL6A NXP
  pack: NXP.MIMXRT1064_DFP.10.0.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x00000000,0x020000) IROM(0x70000000,0x400000) XRAM(0x20200000,0x0c0000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rtthread
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: __CC_ARM, SKIP_SYSCLK_INIT, NDEBUG, __FPU_PRESENT=1, CPU_MIMXRT1064DVL6A, STD=C99, XIP_BOOT_HEADER_ENABLE=1, FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL, XIP_EXTERNAL_FLASH=1, EVK_MCIMXRM, RT_USING_ARM_LIBC
  c misc: --library_interface=armcc --library_type=standardlib --diag_suppress=66,1296,186
  c include: .;..\..\..\..\..\..\NXP\RTT_BSP\imxrt_bsp\include;applications;board;board\MCUX_Config;board\ports;..\Libraries\drivers;..\Libraries\drivers\config;xip;..\..\..\..\..\..\NXP\RTT_BSP\imxrt_bsp\libcpu\arm\common;..\..\..\..\..\..\NXP\RTT_BSP\imxrt_bsp\libcpu\arm\cortex-m7;..\..\..\..\..\..\NXP\RTT_BSP\imxrt_bsp\components\drivers\include;..\..\..\..\..\..\NXP\RTT_BSP\imxrt_bsp\components\drivers\include;..\..\..\..\..\..\NXP\RTT_BSP\imxrt_bsp\components\drivers\include;..\..\..\..\..\..\NXP\RTT_BSP\imxrt_bsp\components\drivers\include;..\..\..\..\..\..\NXP\RTT_BSP\imxrt_bsp\components\finsh;..\..\..\..\..\..\NXP\RTT_BSP\imxrt_bsp\components\libc\compilers\armlibc;..\..\..\..\..\..\NXP\RTT_BSP\imxrt_bsp\components\libc\compilers\common;..\Libraries\MIMXRT1064\CMSIS\Include;..\Libraries\MIMXRT1064\MIMXRT1064;..\Libraries\MIMXRT1064\MIMXRT1064\drivers;..\Libraries\MIMXRT1064\MIMXRT1064\arm
  memory RVCT4: ROM 0x70000000 size 0x400000
  memory RVCT6: RAM 0x20200000 size 0xc0000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\board\linker_scripts\link.sct
  link misc: --keep=*(.boot_hdr.ivt)--keep=*(.boot_hdr.boot_data)--keep=*(.boot_hdr.dcd_data)--keep=*(.boot_hdr.conf)
  group Kernel
    ../../../../../../NXP/RTT_BSP/imxrt_bsp/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group Applications
    applications/: main.c
  group Drivers
    board/: board.c
    board/MCUX_Config/: clock_config.c pin_mux.c
    ../Libraries/drivers/: drv_gpio.c drv_uart.c
  group xip
    xip/: evkmimxrt1064_flexspi_nor_config.c evkmimxrt1064_sdram_ini_dcd.c fsl_flexspi_nor_boot.c
  group cpu
    ../../../../../../NXP/RTT_BSP/imxrt_bsp/libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../../../../../NXP/RTT_BSP/imxrt_bsp/libcpu/arm/cortex-m7/: cpuport.c context_rvds.S
  group DeviceDrivers
    ../../../../../../NXP/RTT_BSP/imxrt_bsp/components/drivers/clock_time/: clock_time_core.c
    ../../../../../../NXP/RTT_BSP/imxrt_bsp/components/drivers/misc/: pin.c
    ../../../../../../NXP/RTT_BSP/imxrt_bsp/components/drivers/serial/: serial.c
    ../../../../../../NXP/RTT_BSP/imxrt_bsp/components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
  group finsh
    ../../../../../../NXP/RTT_BSP/imxrt_bsp/components/finsh/: shell.c symbol.c cmd.c msh.c msh_cmd.c msh_file.c
  group libc
    ../../../../../../NXP/RTT_BSP/imxrt_bsp/components/libc/compilers/armlibc/: libc.c mem_std.c stubs.c time.c
    ../../../../../../NXP/RTT_BSP/imxrt_bsp/components/libc/compilers/common/: gmtime_r.c
  group Libraries
    ../Libraries/MIMXRT1064/MIMXRT1064/: system_MIMXRT1064.c
    ../Libraries/MIMXRT1064/MIMXRT1064/drivers/: fsl_common.c fsl_clock.c fsl_cache.c fsl_gpio.c fsl_lpuart.c
    ../Libraries/MIMXRT1064/MIMXRT1064/arm/: startup_MIMXRT1064.s
