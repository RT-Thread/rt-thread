# Keil uVision project project.uvproj, settings and files
target rt-thread (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: M453VG6AE Nuvoton
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(50000000) CPUTYPE("Cortex-M4") FPU2
  output: project
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: INIT_SYSCLK_AT_BOOTING
  c include: .;..\..\components\drivers\include;..\..\components\finsh;..\..\include;..\..\libcpu\arm\cortex-m4;..\..\libcpu\arm\common;.\applications;.\drivers;.\Libraries\CMSIS\Include;.\Libraries\Device\Nuvoton\M451Series\Include;.\Libraries\StdDriver\inc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Applications
    ./applications/: application.c startup.c
  group Drivers
    ./drivers/: board.c led.c usart.c
  group CMSIS
    ./Libraries/Device/Nuvoton/M451Series/Source/: system_M451Series.c
    ./Libraries/Device/Nuvoton/M451Series/Source/ARM/: startup_M451Series.s
  group M451_StdDriver
    ./Libraries/StdDriver/src/: sys.c clk.c gpio.c acmp.c can.c crc.c dac.c eadc.c ebi.c fmc.c i2c.c pdma.c pwm.c rtc.c sc.c scuart.c spi.c timer.c tk.c uart.c usbd.c wdt.c wwdt.c
  group Kernel
    ../../src/: timer.c clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c
  group CORTEX-M4
    ../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
    ../../libcpu/arm/common/: showmem.c backtrace.c div0.c
  group DeviceDrivers
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/src/: workqueue.c completion.c dataqueue.c pipe.c portal.c ringbuffer.c
  group finsh
    ../../components/finsh/: finsh_vm.c shell.c symbol.c cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c
