# Keil uVision project project.uvproj, settings and files
target RT-Thread LPC17xx (ARM-ADS)
  device: LPC1788 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: rtthread-lpc
  c flags: Optim=1
  c define: RT_USING_LIBC, RT_USING_ARMLIBC, __STDC_LIMIT_MACROS, __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND
  c include: drivers;..\..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\..\libcpu\arm\cortex-m3;..\..\..\..\libcpu\arm\common;..\..\..\..\components\libc\compilers\common\include;CMSIS\CM3\DeviceSupport\NXP\LPC177x_8x;..\..\..\..\components\drivers\include;..\..\..\..\components\dfs\dfs_v1\filesystems\elmfat;CMSIS\CM3\CoreSupport;applications;..\..\..\..\components\finsh;..\..\..\..\components\libc\posix\io\epoll;..\..\..\..\components\dfs\dfs_v1\filesystems\devfs;..\..\..\..\components\drivers\include;..\..\..\..\include;..\..\..\..\components\libc\posix\io\eventfd;..\..\..\..\components\libc\posix\io\poll;.;..\..\..\..\components\libc\compilers\common\extension;..\..\..\..\components\drivers\include;..\..\..\..\components\drivers\include;..\..\..\..\components\dfs\dfs_v1\include;..\..\..\..\components\libc\posix\ipc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group Applications
    applications/: application.c startup.c
  group CMSIS
    CMSIS/CM3/CoreSupport/: core_cm3.c
    CMSIS/CM3/DeviceSupport/NXP/LPC177x_8x/: system_LPC177x_8x.c
    CMSIS/CM3/DeviceSupport/NXP/LPC177x_8x/startup/arm/: startup_LPC177x_8x.s
  group Compiler
    ../../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../../components/drivers/core/: device.c
    ../../../../components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../components/drivers/pin/: pin.c
    ../../../../components/drivers/serial/: serial.c
  group Drivers
    drivers/: lpc177x_8x_emc.c uart.c lpc177x_8x_pinsel.c lpc177x_8x_uart.c board.c lpc17xx_lcd.c sdram.c drv_glcd.c lpc177x_8x_clkpwr.c
  group Filesystem
    ../../../../components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    ../../../../components/dfs/dfs_v1/filesystems/elmfat/: dfs_elm.c ff.c ffunicode.c
    ../../../../components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    ../../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c msh_file.c
  group Kernel
    ../../../../src/: clock.c components.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
    ../../../../src/klibc/: kstdio.c kstring.c
  group libcpu
    ../../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../../libcpu/arm/cortex-m3/: context_rvds.S cpuport.c
