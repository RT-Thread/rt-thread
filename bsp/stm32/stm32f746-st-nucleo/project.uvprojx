# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F746ZGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.14.0
  cpu: IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: RT_USING_ARM_LIBC, USE_HAL_DRIVER, STM32F746xx, __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND
  c include: applications;.;..\..\..\libcpu\arm\common;..\..\..\libcpu\arm\cortex-m7;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\spi;..\..\..\components\drivers\include;..\..\..\components\drivers\include;board;board\CubeMX_Config\Inc;board\ports;..\libraries\HAL_Drivers;..\libraries\HAL_Drivers\config;..\..\..\components\dfs\include;..\..\..\components\dfs\filesystems\devfs;..\..\..\components\finsh;.;..\..\..\include;..\..\..\components\libc\compilers\armlibc;..\..\..\components\libc\compilers\common;..\..\..\components\libc\compilers\common\nogcc;..\libraries\STM32F7xx_HAL\STM32F7xx_HAL_Driver\Inc;..\libraries\STM32F7xx_HAL\CMSIS\Device\ST\STM32F7xx\Include;..\libraries\STM32F7xx_HAL\CMSIS\Include;..\..\..\components\net\lwip-2.1.2\src;..\..\..\components\net\lwip-2.1.2\src\include;..\..\..\components\net\lwip-2.1.2\src\arch\include;..\..\..\components\net\lwip-2.1.2\src\include\netif;..\..\..\components\net\lwip-2.1.2\src\include\compat\posix;..\..\..\examples\utest\testcases\kernel
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20010000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group CPU
    ../../../libcpu/arm/common/: div0.c showmem.c backtrace.c
    ../../../libcpu/arm/cortex-m7/: context_rvds.S cpuport.c cpu_cache.c
  group DeviceDrivers
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/rtc/: soft_rtc.c rtc.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/spi/: spi_core.c spi_dev.c
    ../../../components/drivers/src/: workqueue.c ringbuffer.c waitqueue.c completion.c pipe.c ringblk_buf.c dataqueue.c
  group Drivers
    board/: board.c
    board/CubeMX_Config/Src/: stm32f7xx_hal_msp.c
    ../libraries/STM32F7xx_HAL/CMSIS/Device/ST/STM32F7xx/Source/Templates/arm/: startup_stm32f746xx.s
    ../libraries/HAL_Drivers/: drv_gpio.c drv_usart.c drv_common.c drv_spi.c
  group Filesystem
    ../../../components/dfs/src/: dfs_posix.c dfs_poll.c dfs_file.c dfs.c dfs_fs.c dfs_select.c
    ../../../components/dfs/filesystems/devfs/: devfs.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c msh_file.c
  group Kernel
    ../../../src/: device.c mem.c kservice.c thread.c mempool.c idle.c clock.c timer.c ipc.c irq.c object.c scheduler.c components.c
  group libc
    ../../../components/libc/compilers/armlibc/: mem_std.c syscalls.c libc.c stdio.c
    ../../../components/libc/compilers/common/: unistd.c time.c stdlib.c delay.c
  group Libraries
    ../libraries/STM32F7xx_HAL/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_uart_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_sram.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_crc.c stm32f7xx_hal_spi_ex.c stm32f7xx_hal_usart.c stm32f7xx_hal_rcc.c stm32f7xx_hal_cec.c stm32f7xx_hal_cryp.c stm32f7xx_hal_gpio.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_exti.c stm32f7xx_hal_rtc.c stm32f7xx_hal_cryp_ex.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma.c stm32f7xx_hal_spi.c stm32f7xx_hal_uart.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rng.c stm32f7xx_hal_crc_ex.c
    ../libraries/STM32F7xx_HAL/CMSIS/Device/ST/STM32F7xx/Source/Templates/: system_stm32f7xx.c
  group lwIP
    ../../../components/net/lwip-2.1.2/src/api/: netdb.c sockets.c netifapi.c tcpip.c netbuf.c api_lib.c err.c api_msg.c if_api.c
    ../../../components/net/lwip-2.1.2/src/core/: ip.c netif.c sys.c altcp_alloc.c init.c memp.c raw.c tcp_out.c inet_chksum.c stats.c altcp.c tcp_in.c dns.c timeouts.c udp.c altcp_tcp.c pbuf.c def.c tcp.c
    ../../../components/net/lwip-2.1.2/src/core/ipv4/: autoip.c ip4_addr.c dhcp.c etharp.c ip4.c ip4_frag.c icmp.c igmp.c
    ../../../components/net/lwip-2.1.2/src/netif/: ethernet.c ethernetif.c lowpan6.c
    ../../../components/net/lwip-2.1.2/src/arch/: sys_arch.c
    ../../../components/net/lwip-2.1.2/src/apps/ping/: ping.c
