# IAR project project.ewp, settings and files
configuration rtthread (ARM, debug)
  General.OGChipSelectEditMenu: STM32H750VB ST STM32H750VB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; _DLIB_FILE_DESCRIPTOR; STM32H750xx; __RTTHREAD__; USE_HAL_DRIVER; __RT_IPC_SOURCE__; __RT_KERNEL_SOURCE__
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\components\fal\inc; ..\libraries\HAL_Drivers\drivers; ..\..\..\include; ..\libraries\HAL_Drivers\drivers\drv_flash; ..\libraries\HAL_Drivers\drivers\config; ..\..\..\components\libc\posix\ipc; ..\libraries\STM32H7xx_HAL\CMSIS\Device\ST\STM32H7xx\Include; ..\..\..\components\libc\compilers\common\include; ..\..\..\components\dfs\dfs_v1\include; ..\..\..\components\drivers\spi\sfud\inc; ..\libraries\STM32H7xx_HAL\STM32H7xx_HAL_Driver\Inc; ..\..\..\libcpu\arm\common; ..\..\..\components\libc\posix\io\eventfd; ..\..\..\components\drivers\phy; ..\..\..\components\libc\posix\io\poll; ..\..\..\libcpu\arm\cortex-m7; ..\libraries\HAL_Drivers\CMSIS\Include; ..\..\..\components\finsh; ..\..\..\components\libc\compilers\common\extension; ..\libraries\HAL_Drivers; ..\..\..\components\drivers\include; ..\..\..\components\drivers\spi; ..\..\..\components\libc\compilers\common\extension\fcntl\octal; ..\libraries\STM32H7xx_HAL\STM32H7xx_HAL_Driver\Inc\Legacy; board\port\st7735; board; .; board\port; ..\..\..\components\libc\posix\io\epoll; ..\..\..\components\drivers\smp_call; board\CubeMX_Config\Inc; applications; ..\..\..\components\dfs\dfs_v1\filesystems\devfs
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../../rtthread.bin
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: main.c
  group Compiler
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/misc/: rt_drv_pwm.c
    ../../../components/drivers/mtd/: mtd_nor.c
    ../../../components/drivers/pin/: dev_pin.c
    ../../../components/drivers/serial/: dev_serial_v2.c
    ../../../components/drivers/spi/: dev_qspi_core.c dev_spi.c dev_spi_core.c dev_spi_flash_sfud.c
    ../../../components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
  group Drivers
    ../libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32H7xx/Source/Templates/iar/: startup_stm32h750xx.s
    board/CubeMX_Config/Src/: stm32h7xx_hal_msp.c
    board/: board.c
    board/port/: drv_lcd_spi.c drv_qspi_flash.c
    board/port/st7735/: lcd.c logo.c st7735.c st7735_reg.c
    ../libraries/HAL_Drivers/drivers/drv_flash/: drv_flash_h7.c
    ../libraries/HAL_Drivers/drivers/: drv_gpio.c drv_pwm.c drv_qspi.c drv_spi.c drv_tim.c drv_usart_v2.c
    ../libraries/HAL_Drivers/: drv_common.c
  group Fal
    ../../../components/fal/samples/porting/: fal_flash_sfud_port.c
    ../../../components/fal/src/: fal_flash.c fal_rtt.c fal.c fal_partition.c
  group Filesystem
    ../../../components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    ../../../components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    ../../../components/finsh/: msh_parse.c msh.c msh_file.c shell.c cmd.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    ../../../src/klibc/: rt_vsscanf.c rt_vsnprintf_tiny.c kstdio.c kstring.c kerrno.c
  group libcpu
    ../../../libcpu/arm/common/: div0.c showmem.c
    ../../../libcpu/arm/cortex-m7/: context_iar.S cpu_cache.c cpuport.c
  group Libraries
    ../libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
    ../libraries/STM32H7xx_HAL/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_usart.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_nor.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_pwr.c stm32h7xx_hal_cortex.c stm32h7xx_hal_tim.c stm32h7xx_hal_flash.c stm32h7xx_hal_rng.c stm32h7xx_hal_mdma.c stm32h7xx_hal_comp.c stm32h7xx_hal_dma.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_cryp.c stm32h7xx_hal_crc.c stm32h7xx_hal_sram.c stm32h7xx_hal.c stm32h7xx_hal_uart.c stm32h7xx_hal_rcc.c stm32h7xx_hal_qspi.c stm32h7xx_hal_gpio.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_cryp_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_cec.c stm32h7xx_hal_lptim.c stm32h7xx_hal_pwr_ex.c
