# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32MP157AACx:Cortex-M4 STMicroelectronics
  pack: Keil.STM32MP1xx_DFP.1.3.0
  cpu: IRAM(0x10020000,0x00020000) IRAM2(0x10040000,0x00020000) IROM(0x10000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32MP157Axx, __LOG_TRACE_IO_, METAL_MAX_DEVICE_REGIONS=2, VIRTIO_SLAVE_ONLY, __RTTHREAD__, CORE_CM4, NO_ATOMIC_64_SUPPORT, METAL_INTERNAL
  c include: .;..\..\..\components\drivers\include;board;..\..\..\libcpu\arm\cortex-m4;..\..\..\components\finsh;..\libraries\HAL_Drivers\nano;..\libraries\HAL_Drivers;..\..\..\components\net\utest;..\..\..\libcpu\arm\common;board\CubeMX_Config\CM4\Inc;applications;..\..\..\components\drivers\smp_call;board\ports;..\..\..\include;..\..\..\components\drivers\phy
  memory RVCT4: ROM 0x10000000 size 0x30000
  memory RVCT9: RAM 0x10030000 size 0x10000
  memory RVCT10: RAM 0x10040000 size 0x20000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group CPU
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group Drivers
    ../libraries/HAL_Drivers/: drv_common.c
    ../libraries/HAL_Drivers/nano/: drv_console.c drv_gpio.c
    board/CubeMX_Config/CM4/Src/: stm32mp1xx_hal_msp.c
    board/: board.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group Libc
    ../../../src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
