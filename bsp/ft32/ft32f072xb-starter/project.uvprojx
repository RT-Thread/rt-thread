# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: FT32F072RBATx FMD
  pack: FMD.FT32F0xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x00006000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: FT32F072xB, __RTTHREAD__, RT_USING_ARM_LIBC, __CLK_TCK=RT_TICK_PER_SECOND
  c include: applications;..\..\..\components\libc\compilers\common;..\..\..\components\libc\compilers\common\extension;..\..\..\libcpu\arm\common;..\..\..\libcpu\arm\cortex-m0;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;board;..\libraries\Drivers;..\..\..\components\finsh;.;..\..\..\include;..\libraries\FT32F0xx\CMSIS\FT32F0xx\Include;..\libraries\FT32F0xx\FT32F0xx_Driver\Inc;..\libraries\FT32F0xx\FT32F0xx_Driver\templates\Inc;..\..\..\components\libc\posix\io\poll;..\..\..\components\libc\posix\io\stdio;..\..\..\components\libc\posix\ipc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x6000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscalls.c syscall_mem.c
    ../../../components/libc/compilers/common/: time.c stdlib.c
  group CPU
    ../../../libcpu/arm/common/: backtrace.c showmem.c div0.c
    ../../../libcpu/arm/cortex-m0/: cpuport.c context_rvds.S
  group DeviceDrivers
    ../../../components/drivers/ipc/: pipe.c waitqueue.c workqueue.c completion.c ringbuffer.c dataqueue.c ringblk_buf.c
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/serial/: serial.c
  group Drivers
    ../libraries/FT32F0xx/CMSIS/FT32F0xx/source/arm/: startup_ft32f072xb.s
    board/: board.c
    ../libraries/Drivers/: drv_gpio.c drv_usart.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c cmd.c
  group Kernel
    ../../../src/: components.c kservice.c idle.c mem.c thread.c mempool.c clock.c ipc.c object.c device.c timer.c scheduler.c irq.c
  group Libraries
    ../libraries/FT32F0xx/FT32F0xx_Driver/Src/: ft32f0xx_crs.c ft32f0xx_gpio.c ft32f0xx_pwr.c ft32f0xx_div.c ft32f0xx_crc.c ft32f0xx_syscfg.c ft32f0xx_usart.c ft32f0xx_dma.c ft32f0xx_tim.c ft32f0xx_comp.c ft32f0xx_debug.c ft32f0xx_rcc.c ft32f0xx_exti.c ft32f0xx_iwdg.c ft32f0xx_misc.c ft32f0xx_opa.c
    ../libraries/FT32F0xx/CMSIS/FT32F0xx/source/: system_ft32f0xx.c
