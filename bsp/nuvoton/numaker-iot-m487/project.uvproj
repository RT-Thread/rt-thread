# Keil uVision project project.uvproj, settings and files
target rtthread-m480 (ARM-ADS)
  device: M487JIDAE Nuvoton
  cpu: IRAM(0x20000000-0x20027FFF) IROM(0-0x7FFFF) CLOCK(192000000) CPUTYPE("Cortex-M4") FPU2
  output: rtthread +hex
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1
  c define: __RTTHREAD__, RT_USING_ARM_LIBC, __CLK_TCK=RT_TICK_PER_SECOND
  c misc: --c99
  c include: applications;.;..\..\..\components\net\at\include;..\..\..\components\net\at\at_socket;packages\at_device-latest\inc;packages\at_device-latest\class\esp8266;..\libraries\m480\CMSIS\Include;..\..\..\components\libc\compilers\common;..\..\..\components\libc\compilers\common\nogcc;..\..\..\libcpu\arm\common;..\..\..\libcpu\arm\cortex-m4;..\..\..\components\drivers\audio;..\..\..\components\drivers\include;..\..\..\components\drivers\hwcrypto;.;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\spi;..\..\..\components\drivers\include;..\..\..\components\drivers\spi\sfud\inc;..\..\..\components\drivers\include;..\..\..\components\drivers\include;board;board\NuClockConfig;board\NuPinConfig;..\libraries\m480\Device\Nuvoton\M480\Include;..\libraries\m480\rtt_port;packages\fal-latest\inc;..\..\..\components\dfs\include;..\..\..\components\dfs\filesystems\devfs;..\..\..\components\dfs\filesystems\elmfat;..\..\..\components\finsh;.;..\..\..\include;..\libraries\m480\StdDriver\inc;..\libraries\m480\USBHostLib\inc;..\libraries\nu_packages\BMX055;..\libraries\nu_packages\BMX055\libraries\BMA2x2_driver;..\libraries\nu_packages\BMX055\libraries\BMG160_driver;..\libraries\nu_packages\BMX055\libraries\BMM050_driver;..\libraries\nu_packages\Demo;..\libraries\nu_packages\AudioCodec;..\libraries\nu_packages\NuUtils\inc;..\..\..\components\libc\posix\io;..\..\..\components\libc\posix\io\poll;..\..\..\components\libc\posix\ipc;..\..\..\components\drivers\usb\usbdevice;..\..\..\components\drivers\usb\usbhost;..\..\..\components\drivers\usb\usbhost\class;..\..\..\components\drivers\usb\usbhost\core;..\..\..\components\drivers\usb\usbhost\include;..\..\..\components\drivers\include;..\..\..\components\net\netdev\include;..\..\..\components\net\sal_socket\include;..\..\..\components\net\sal_socket\include\socket;..\..\..\components\net\sal_socket\impl;..\..\..\components\net\sal_socket\include\dfs_net;..\..\..\components\net\sal_socket\include\socket\sys_socket;..\..\..\components\drivers\sensors;..\..\..\components\drivers\include;..\..\..\components\utilities\utest;..\..\..\examples\utest\testcases\kernel
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  scatter file: .\linking_scripts\m480_flash.sct
  group Applications
    applications/: main.c mnt.c
  group AT
    ../../../components/net/at/src/: at_utils.c at_client.c at_cli.c
    ../../../components/net/at/at_socket/: at_socket.c
  group at_device
    packages/at_device-latest/class/esp8266/: at_device_esp8266.c at_socket_esp8266.c
    packages/at_device-latest/src/: at_device.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: libc_syms.c syscalls.c syscall_mem.c
    ../../../components/libc/compilers/common/: stdlib.c time.c
  group CPU
    ../../../libcpu/arm/common/: div0.c backtrace.c showmem.c
    ../../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../../components/drivers/audio/: audio_pipe.c audio.c
    ../../../components/drivers/can/: can.c
    ../../../components/drivers/hwcrypto/: hw_symmetric.c hwcrypto.c hw_rng.c hw_crc.c hw_hash.c
    ../../../components/drivers/hwtimer/: hwtimer.c
    ../../../components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    ../../../components/drivers/misc/: adc.c rt_drv_pwm.c pin.c
    ../../../components/drivers/pm/: lptimer.c pm.c
    ../../../components/drivers/rtc/: rtc.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    ../../../components/drivers/spi/: spi_core.c spi_dev.c qspi_core.c spi_flash_sfud.c
    ../../../components/drivers/src/: workqueue.c ringblk_buf.c ringbuffer.c dataqueue.c pipe.c completion.c waitqueue.c
    ../../../components/drivers/watchdog/: watchdog.c
  group Drivers
    board/NuPinConfig/: nutool_pincfg.c
    board/: board_dev.c
    board/NuClockConfig/: nutool_modclkcfg.c
    ../libraries/m480/Device/Nuvoton/M480/Source/: system_M480.c
    ../libraries/m480/Device/Nuvoton/M480/Source/ARM/: startup_M480.s
    ../libraries/m480/rtt_port/: drv_sdh.c drv_clk.c drv_hsusbd.c drv_ecap.c drv_can.c drv_gpio.c drv_ebi.c drv_usbd.c drv_spii2s.c drv_fmc.c drv_common.c drv_rtc.c drv_crypto.c drv_qspi.c drv_trng.c drv_i2s.c drv_epwm.c drv_timer_capture.c drv_uart.c drv_tpwm.c drv_crc.c drv_qei.c drv_timer.c drv_scuart.c drv_i2c.c drv_epwm_capture.c drv_eadc.c drv_wdt.c drv_bpwm_capture.c drv_uuart.c drv_uspi.c drv_hsotg.c drv_emac.c drv_softi2c.c drv_ui2c.c drv_bpwm.c drv_pdma.c drv_usbhost.c drv_spi.c
  group fal
    packages/fal-latest/src/: fal_flash.c fal_partition.c fal.c fal_rtt.c
  group Filesystem
    ../../../components/dfs/src/: dfs_posix.c dfs_fs.c dfs.c dfs_file.c
    ../../../components/dfs/filesystems/devfs/: devfs.c
    ../../../components/dfs/filesystems/elmfat/: dfs_elm.c ffunicode.c ff.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c msh_file.c cmd.c
  group Kernel
    ../../../src/: components.c device.c thread.c mem.c scheduler.c timer.c idle.c irq.c object.c signal.c mempool.c clock.c kservice.c ipc.c
  group Libraries
    ../libraries/m480/StdDriver/src/: nu_ecap.c nu_spim.c nu_epwm.c nu_spi.c nu_timer_pwm.c nu_clk.c nu_i2c.c nu_pdma.c nu_acmp.c nu_crc.c nu_timer.c nu_fmc.c nu_bpwm.c nu_sys.c nu_wwdt.c nu_crypto.c nu_eadc.c nu_qei.c nu_qspi.c nu_sdh.c nu_can.c nu_uart.c nu_trng.c nu_ebi.c nu_dac.c nu_gpio.c nu_usci_spi.c nu_usci_i2c.c nu_emac.c nu_usbd.c nu_rtc.c nu_scuart.c nu_ccap.c nu_sc.c nu_hsusbd.c nu_wdt.c nu_usci_uart.c nu_i2s.c
  group m480_usbhostlib
    ../libraries/m480/USBHostLib/src/: usb_core.c ehci_iso.c ehci.c mem_alloc.c ohci.c
  group nu_pkgs_bmx055
    ../libraries/nu_packages/BMX055/libraries/BMG160_driver/: bmg160.c
    ../libraries/nu_packages/BMX055/libraries/BMA2x2_driver/: bma2x2.c
    ../libraries/nu_packages/BMX055/: sensor_bmx055.c
    ../libraries/nu_packages/BMX055/libraries/BMM050_driver/: bmm050.c
  group nu_pkgs_demo
    ../libraries/nu_packages/Demo/: usbd_cdc_vcom_echo.c slcd_show_tick.c usbd_hid_dance_mouse.c
  group nu_pkgs_nau88l25
    ../libraries/nu_packages/AudioCodec/: audio_test.c acodec_nau88l25.c
  group POSIX
    ../../../components/libc/posix/io/: select.c
    ../../../components/libc/posix/io/poll/: poll.c
  group rt_usbd
    ../../../components/drivers/usb/usbdevice/class/: hid.c
    ../../../components/drivers/usb/usbdevice/core/: usbdevice_core.c usbdevice.c
  group rt_usbh
    ../../../components/drivers/usb/usbhost/class/: udisk.c mass.c
    ../../../components/drivers/usb/usbhost/core/: hub.c usbhost.c usbhost_core.c driver.c
  group SAL
    ../../../components/net/netdev/src/: netdev.c netdev_ipaddr.c
    ../../../components/net/sal_socket/dfs_net/: dfs_net.c
    ../../../components/net/sal_socket/impl/: af_inet_at.c
    ../../../components/net/sal_socket/socket/: net_sockets.c net_netdb.c
    ../../../components/net/sal_socket/src/: sal_socket.c
  group Sensors
    ../../../components/drivers/sensors/: sensor_cmd.c sensor.c
  group UTest
    ../../../components/utilities/utest/: utest.c
