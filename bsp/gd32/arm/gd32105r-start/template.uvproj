# Keil uVision project template.uvproj, settings and files
target rt-thread (ARM-ADS)
  device: GD32F105RC GigaDevice
  cpu: IRAM(0x20000000-0x20018000) IROM(0x08000000-0x08040000) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: rtthread +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\..\Library\Firmware\GD32F10x_standard_peripheral\Include;..\..\..\Library\Firmware\CMSIS\GD\GD32F10x\Include;..\..\..\Library\Utilities;..\
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application
    ../: main.c gd32f10x_it.c
  group CMSIS
    ../../../Library/Firmware/CMSIS/GD/GD32F10x/Source/: system_gd32f10x.c
  group GD32F10x_Peripherals
    ../../../Library/Firmware/GD32F10x_standard_peripheral/Source/: gd32f10x_adc.c gd32f10x_can.c gd32f10x_crc.c gd32f10x_ctc.c gd32f10x_dac.c gd32f10x_dbg.c gd32f10x_dci.c gd32f10x_dma.c gd32f10x_enet.c gd32f10x_exmc.c gd32f10x_exti.c gd32f10x_fmc.c gd32f10x_fwdgt.c gd32f10x_gpio.c gd32f10x_i2c.c gd32f10x_ipa.c gd32f10x_iref.c gd32f10x_misc.c gd32f10x_pmu.c gd32f10x_rcu.c gd32f10x_rtc.c gd32f10x_sdio.c gd32f10x_spi.c gd32f10x_syscfg.c gd32f10x_timer.c gd32f10x_tli.c gd32f10x_trng.c gd32f10x_usart.c gd32f10x_wwdgt.c
  group GD32F10x_START
    ../../../Library/Utilities/: gd32f105r_start.c
  group Startup
    ../../../Library/Firmware/CMSIS/GD/GD32F10x/Source/ARM/: startup_gd32f10x_cl.s
  group Doc
    ../: readme.txt
