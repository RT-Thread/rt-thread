# Keil uVision project project.uvprojx, settings and files
target rtthread (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: rtthread +hex
  AfterMake: fromelf.exe --bin -o  .//@L.bin  ./build/@L.axf
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: __STDC_LIMIT_MACROS, RT_USING_ARMLIBC, __CLK_TCK=RT_TICK_PER_SECOND, __RTTHREAD__, RT_USING_LIBC
  c include: libraries\Hal_lib\inc;applications;..\..\components\net\utest;..\..\components\drivers\phy;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\libc\compilers\common\extension;..\..\components\drivers\include;..\..\components\dfs\dfs_v1\include;drivers\lcd;libraries\CMSIS_and_startup\CMSIS;..\..\libcpu\arm\cortex-m4;..\..\components\finsh;drivers;..\..\components\libc\posix\io\epoll;..\..\components\libc\compilers\common\include;..\..\components\drivers\include;..\..\components\drivers\include;libraries\CMSIS_and_startup;..\..\components\libc\posix\ipc;..\..\components\libc\posix\io\poll;..\..\components\drivers\smp_call;..\..\include;..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\components\dfs\dfs_v1\filesystems\devfs;..\..\libcpu\arm\common;..\..\components\libc\posix\io\eventfd;.;..\..\components\drivers\include
  memory RVCT4: ROM 0x70020000 size 0x200000
  memory RVCT9: RAM 0x70220000 size 0x5dffff
  group Applications
    applications/: main.c
  group CPU
    ../../libcpu/arm/common/: div0.c showmem.c
    ../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../components/drivers/core/: device.c
    ../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../components/drivers/pin/: dev_pin.c
    ../../components/drivers/serial/: dev_serial.c
  group Drivers
    drivers/: board.c drv_uart.c drv_gpio.c
  group Filesystem
    ../../components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    ../../components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c
  group Finsh
    ../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group Libc
    ../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
  group TKM32_Lib
    libraries/Hal_lib/src/: HAL_can.c HAL_dma.c HAL_dma_bak.c HAL_exti.c HAL_gpio.c HAL_i2c.c HAL_iwdg.c HAL_misc.c HAL_pwr.c HAL_rcc.c HAL_spi.c HAL_syscfg.c HAL_tim.c HAL_uart.c HAL_wwdg.c
    libraries/CMSIS_and_startup/: sys.c startup_Tk499.s
