# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: GD32F303xE GD GD32F303xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; _DLIB_FILE_DESCRIPTOR; _DLIB_THREAD_SUPPORT; __RTTHREAD__; USE_STDPERIPH_DRIVER; GD32F30X_HD
  ICCARM.CCIncludePath2: Libraries\CMSIS\GD\GD32F30x\Include; ..\..\include; ..\..\libcpu\arm\common; ..\..\components\drivers\include; ..\..\components\dfs\filesystems\devfs; ..\..\components\libc\posix\ipc; drivers; .; ..\..\libcpu\arm\cortex-m4; ..\..\components\drivers\spi\sfud\inc; Libraries\CMSIS; ..\..\components\dfs\include; ..\..\components\libc\compilers\common\include; ..\..\components\drivers\spi; applications; ..\..\components\libc\compilers\common\extension\fcntl\octal; Libraries\GD32F30x_standard_peripheral\Include; ..\..\components\finsh; ..\..\components\dfs\filesystems\elmfat; ..\..\components\libc\compilers\common\extension; ..\..\components\libc\posix\io\poll; ..\..\components\libc\posix\io\stdio
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: project.srec
  ILINK.IlinkOutputFile: GD32F450Z_EVAL.out
  ILINK.IlinkIcfFile: gd32_rom.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; _DLIB_FILE_DESCRIPTOR; _DLIB_THREAD_SUPPORT; __RTTHREAD__; USE_STDPERIPH_DRIVER; GD32F30X_HD
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: main.c
  group Compiler
    ../../components/libc/compilers/common/: cctype.c cstdio.c cstdlib.c cstring.c ctime.c cwchar.c
    ../../components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
  group CPU
    ../../libcpu/arm/common/: div0.c showmem.c
    ../../libcpu/arm/cortex-m4/: context_iar.S cpuport.c
  group DeviceDrivers
    ../../components/drivers/i2c/: i2c_core.c i2c_dev.c
    ../../components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../components/drivers/misc/: pin.c
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/spi/sfud/src/: sfud.c
    ../../components/drivers/spi/: spi_core.c spi_dev.c spi_flash_sfud.c
  group Drivers
    drivers/: drv_gpio.c drv_spi.c drv_i2c.c drv_spi_flash.c drv_usart.c board.c
  group Filesystem
    ../../components/dfs/filesystems/devfs/: devfs.c
    ../../components/dfs/filesystems/elmfat/: dfs_elm.c ff.c ffunicode.c
    ../../components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    ../../components/finsh/: shell.c msh.c msh_parse.c cmd.c msh_file.c
  group Kernel
    ../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_up.c thread.c timer.c
  group Libraries
    Libraries/GD32F30x_standard_peripheral/Source/: gd32f30x_exmc.c gd32f30x_rtc.c gd32f30x_bkp.c gd32f30x_ctc.c gd32f30x_wwdgt.c gd32f30x_enet.c gd32f30x_pmu.c gd32f30x_i2c.c gd32f30x_exti.c gd32f30x_crc.c gd32f30x_can.c gd32f30x_gpio.c gd32f30x_dbg.c gd32f30x_spi.c gd32f30x_dma.c gd32f30x_rcu.c gd32f30x_timer.c gd32f30x_misc.c gd32f30x_adc.c gd32f30x_sdio.c gd32f30x_dac.c gd32f30x_usart.c gd32f30x_fmc.c gd32f30x_fwdgt.c
    Libraries/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
    Libraries/CMSIS/GD/GD32F30x/Source/IAR/: startup_gd32f30x_hd.s
