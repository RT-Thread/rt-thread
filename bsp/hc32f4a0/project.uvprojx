# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060020::V5.06 (build 20)::ARMCC)
  device: HC32F4A0SITB HDSC
  pack: HDSC.HC32F4A0.1.0.0
  cpu: IROM(0x00000000,0x200000) IRAM(0x1FFE0000,0x80000)  IRAM2(0X200F0000,0x1000) CPUTYPE("Cortex-M4") FPU2 CLOCK(240000000) ESEL ELITTLE
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: __CLK_TCK=RT_TICK_PER_SECOND, USE_DDL_DRIVER, HC32F4A0, __RTTHREAD__, __DEBUG, RT_USING_ARM_LIBC
  c misc: --diag_suppress=186,66
  c include: applications;.;..\..\libcpu\arm\common;..\..\libcpu\arm\cortex-m4;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\drivers\include;board;drivers;..\..\components\dfs\include;..\..\components\dfs\filesystems\devfs;..\..\components\finsh;Libraries\CMSIS\Include;Libraries\CMSIS\Device\HDSC\HC32F4A0\Include;Libraries\HC32F4A0_StdPeriph_Driver\inc;.;..\..\include;..\..\components\libc\compilers\armlibc;..\..\components\libc\compilers\common;..\..\components\libc\compilers\common\nogcc;..\..\examples\utest\testcases\kernel
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x1fff8000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group CPU
    ../../libcpu/arm/common/: showmem.c div0.c backtrace.c
    ../../libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
  group DeviceDrivers
    ../../components/drivers/misc/: pin.c
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/src/: dataqueue.c ringbuffer.c pipe.c ringblk_buf.c waitqueue.c workqueue.c completion.c
  group Drivers
    board/: board_config.c board.c
    drivers/: drv_gpio.c drv_irq.c drv_usart.c
  group Filesystem
    ../../components/dfs/src/: dfs_posix.c dfs_poll.c dfs_file.c dfs.c dfs_fs.c dfs_select.c
    ../../components/dfs/filesystems/devfs/: devfs.c
  group Finsh
    ../../components/finsh/: shell.c msh.c msh_file.c cmd.c
  group HC32_StdPeriph
    Libraries/HC32F4A0_StdPeriph_Driver/src/: hc32f4a0_icg.c hc32f4a0_dma.c hc32f4a0_clk.c hc32f4a0_sram.c hc32f4a0_pwc.c hc32f4a0_gpio.c hc32f4a0_tmr0.c hc32f4a0_interrupts.c hc32f4a0_efm.c hc32f4a0_usart.c hc32f4a0_utility.c
    Libraries/CMSIS/Device/HDSC/HC32F4A0/Source/ARM/: startup_hc32f4a0.s
    Libraries/CMSIS/Device/HDSC/HC32F4A0/Source/: system_hc32f4a0.c
  group Kernel
    ../../src/: device.c ipc.c components.c mem.c mempool.c irq.c object.c clock.c scheduler.c kservice.c thread.c idle.c timer.c
  group libc
    ../../components/libc/compilers/armlibc/: mem_std.c stdio.c libc.c syscalls.c
    ../../components/libc/compilers/common/: unistd.c stdlib.c delay.c time.c
