# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F334R8Tx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.2.2
  cpu: IRAM(0x20000000,0x00004000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __CLK_TCK=RT_TICK_PER_SECOND, STM32F334x8, __STDC_LIMIT_MACROS, USE_HAL_DRIVER, RT_USING_LIBC, RT_USING_ARMLIBC, __RTTHREAD__
  c include: ..\..\..\components\libc\compilers\common\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\libc\posix\io\eventfd;..\..\..\libcpu\arm\cortex-m4;..\..\..\libcpu\arm\common;applications;.;..\..\..\include;..\libraries\HAL_Drivers;..\libraries\HAL_Drivers\CMSIS\Include;..\..\..\components\drivers\include;..\libraries\HAL_Drivers\drivers;board\CubeMX_Config\Inc;..\..\..\components\libc\posix\io\poll;..\..\..\components\drivers\include;..\libraries\STM32F3xx_HAL\CMSIS\Device\ST\STM32F3xx\Include;..\libraries\HAL_Drivers\drivers\config;..\libraries\STM32F3xx_HAL\STM32F3xx_HAL_Driver\Inc;..\..\..\components\libc\compilers\common\extension;..\..\..\components\libc\posix\ipc;..\..\..\components\drivers\phy;..\..\..\components\drivers\include;..\..\..\components\libc\posix\io\epoll;..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\components\drivers\smp_call;..\..\..\components\finsh;board
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/pin/: dev_pin.c
    ../../../components/drivers/serial/: dev_serial.c
  group Drivers
    ../libraries/HAL_Drivers/drivers/: drv_gpio.c drv_usart.c
    ../libraries/HAL_Drivers/: drv_common.c
    ../libraries/STM32F3xx_HAL/CMSIS/Device/ST/STM32F3xx/Source/Templates/arm/: startup_stm32f334x8.s
    board/CubeMX_Config/Src/: stm32f3xx_hal_msp.c
    board/: board.c
  group Finsh
    ../../../components/finsh/: msh_parse.c shell.c cmd.c msh.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    ../../../src/klibc/: kstring.c rt_vsnprintf_tiny.c kerrno.c kstdio.c rt_vsscanf.c
  group libcpu
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group Libraries
    ../libraries/STM32F3xx_HAL/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal_rcc.c stm32f3xx_hal_usart.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_crc.c stm32f3xx_hal_uart_ex.c stm32f3xx_hal_dma.c stm32f3xx_hal_uart.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_sram.c stm32f3xx_hal_crc_ex.c stm32f3xx_hal_usart_ex.c stm32f3xx_hal.c stm32f3xx_hal_cortex.c stm32f3xx_hal_exti.c stm32f3xx_hal_gpio.c stm32f3xx_hal_cec.c
    ../libraries/STM32F3xx_HAL/CMSIS/Device/ST/STM32F3xx/Source/Templates/: system_stm32f3xx.c
