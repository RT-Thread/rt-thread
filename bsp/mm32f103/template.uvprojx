# Keil uVision project template.uvprojx, settings and files
target RT-Thread MM32F103 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MM32F103 MindMotion
  pack: MindMotion.MM32x103_DFP.1.4.1
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rtthread-mm32
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\mm32f103_rom.sct
  link misc: --keep *.o(.rti_fn.*)   --keep *.o(FSymTab) --keep *.o(VSymTab)
software components: CMSIS:CORE 5.0.1
