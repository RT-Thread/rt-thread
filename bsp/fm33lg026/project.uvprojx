# Keil uVision project project.uvprojx, settings and files
target RT_Thread (ARM-ADS)
  device: FM33LG02X FMSH
  pack: FMSH.FM33LG0XX_DFP.3.0.1
  cpu: IROM(0x00000000,0x20000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: rt-thread +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: RT_USING_ARMLIBC, __CLK_TCK=RT_TICK_PER_SECOND, __STDC_LIMIT_MACROS, USE_HAL_DRIVER, RT_USING_LIBC, FM33LG0XX, __RTTHREAD__
  c include: ..\..\libcpu\arm\cortex-m0;..\..\components\libc\posix\io\poll;libraries\FM33LG0xx_FL_Driver\CMSIS\Include;..\..\components\libc\posix\io\eventfd;..\..\components\drivers\include;..\..\components\libc\compilers\common\extension;..\..\components\libc\compilers\common\include;..\..\components\drivers\smp_call;..\..\components\libc\posix\io\epoll;..\..\components\libc\posix\ipc;..\..\libcpu\arm\common;..\..\components\finsh;..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\components\drivers\include;libraries\HAL_Drivers;..\..\include;libraries\HAL_Drivers\config;..\..\components\net\utest;..\..\components\drivers\include;libraries\FM33LG0xx_FL_Driver\Inc;applications;..\..\components\drivers\include;..\..\components\drivers\include;.;..\..\components\drivers\include;board
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x6000
  group Applications
    applications/: main.c
  group CPU
    ../../libcpu/arm/common/: div0.c showmem.c
    ../../libcpu/arm/cortex-m0/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../components/drivers/core/: device.c
    ../../components/drivers/i2c/: dev_i2c_bit_ops.c dev_i2c_core.c dev_i2c_dev.c
    ../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../components/drivers/pin/: dev_pin.c
    ../../components/drivers/serial/: dev_serial.c
  group Drivers
    board/: board.c
    libraries/FM/FM33xx/Source/Templates/ARM/: startup_fm33lg0xx.s
    libraries/HAL_Drivers/: drv_common.c drv_gpio.c drv_usart.c
  group Finsh
    ../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group FM33LG0xx_FL_Driver
    libraries/FM33LG0xx_FL_Driver/CMSIS/: system_fm33lg0xx.c
    libraries/FM33LG0xx_FL_Driver/Src/: fm33lg0xx_fl_dma.c fm33lg0xx_fl_crc.c fm33lg0xx_fl_cmu.c fm33lg0xx_fl_gpio.c fm33lg0xx_fl_exti.c fm33lg0xx_fl_uart.c fm33lg0xx_fl_lpuart.c fm33lg0xx_fl_i2c.c
  group Kernel
    ../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group Libc
    ../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
