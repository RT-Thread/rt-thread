# IAR project project.ewp, settings and files
configuration rtthread_ram (ARM)
  General.OGChipSelectEditMenu: MIMXRT1189xxx8_M33 NXP MIMXRT1189xxx8_M33
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 61
  General.FPU2: 6
  ICCARM.CCDefines: CPU_MIMXRT1189CVM8C_cm33; MCUXPRESSO_SDK; MCUX_META_BUILD; MIMXRT1189_cm33_SERIES; ARM_MATH_CM33; NDEBUG; __USE_SHMEM; MULTICORE_APP=1; __RTTHREAD__; CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; __RT_IPC_SOURCE__; __RT_KERNEL_SOURCE__
  ICCARM.CCIncludePath2: applications; ..\..\..\..\..\..\libcpu\arm\common; ..\..\..\..\..\..\libcpu\arm\cortex-m33; ..\..\..\..\..\..\components\drivers\include; ..\..\..\..\..\..\components\drivers\phy; ..\..\..\..\..\..\components\drivers\smp_call; board; board\MCUX_Config; board\ports; ..\..\libraries\drivers; ..\..\..\..\..\..\components\finsh; .; ..\..\..\..\..\..\include; ..\..\..\..\..\..\components\libc\compilers\common\include; ..\..\..\..\..\..\components\libc\compilers\common\extension; ..\..\..\..\..\..\components\libc\compilers\common\extension\fcntl\octal; ..\..\..\..\..\..\components\libc\posix\io\epoll; ..\..\..\..\..\..\components\libc\posix\io\eventfd; ..\..\..\..\..\..\components\libc\posix\io\poll; ..\..\..\..\..\..\components\libc\posix\ipc; packages\nxp-imxrt-sdk-latest\MIMXRT1180\CMSIS\Core\Include; packages\nxp-imxrt-sdk-latest\MIMXRT1180\CMSIS\Core\m-profile; packages\nxp-imxrt-sdk-latest\MIMXRT1180\MIMXRT1189; packages\nxp-imxrt-sdk-latest\MIMXRT1180\MIMXRT1189\drivers; packages\nxp-imxrt-sdk-latest\MIMXRT1180\MIMXRT1189\periph; packages\nxp-imxrt-sdk-latest\MIMXRT1180\MIMXRT1189\drivers\cm33; multicore; packages\nxp-imxrt-sdk-latest\MIMXRT1180\multicore\mcmgr\inc; packages\nxp-imxrt-sdk-latest\MIMXRT1180\multicore\mcmgr\inc\platform\imxrt1180; ..\..\..\..\..\..\components\net\utest; xip
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: project.hex
  ILINK.IlinkOutputFile: template.out
  ILINK.IlinkConfigDefines: __use_shmem__=1; __multicore__=1
  ILINK.IlinkIcfFile: board\linker_scripts\MIMXRT1189xxxxx_cm33_ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration rtthread_flexspi_nor (ARM)
  as the first configuration, except:
  OBJCOPY.OOCOutputFile: template.srec
  ILINK.IlinkIcfFile: board\linker_scripts\MIMXRT1189xxxxx_cm33_flexspi_nor.icf
configuration rtthread_flexspi_nor_hyperram (ARM)
  as the first configuration, except:
  OBJCOPY.OOCOutputFile: template.srec
  ILINK.IlinkIcfFile: board\linker_scripts\MIMXRT1189xxxxx_cm33_flexspi_nor_hyperram.icf
  group Applications
    applications/: main.c multicore_thread.c
  group CPU
    ../../../../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../../../../libcpu/arm/cortex-m33/: context_iar.S cpuport.c syscall_iar.S trustzone.c
  group DeviceDrivers
    ../../../../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../../../components/drivers/pin/: dev_pin.c
    ../../../../../../components/drivers/serial/: dev_serial_v2.c
    ../../../../../../components/drivers/core/: device.c
  group Drivers
    board/: board.c
    board/MCUX_Config/: clock_config.c peripherals.c pin_mux.c
    ../../libraries/drivers/: drv_common.c drv_gpio.c drv_uart_v2.c
  group Finsh
    ../../../../../../components/finsh/: cmd.c msh.c msh_parse.c shell.c
  group Kernel
    ../../../../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group Libc
    ../../../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../../../../components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
    ../../../../../../src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
  group Libraries
    packages/nxp-imxrt-sdk-latest/MIMXRT1180/MIMXRT1189/drivers/cm33/: fsl_cache.c
    packages/nxp-imxrt-sdk-latest/MIMXRT1180/MIMXRT1189/drivers/: fsl_clock.c fsl_common.c fsl_common_arm.c fsl_dcdc.c fsl_ele_base_api.c fsl_gpc.c fsl_lpuart.c fsl_memory.c fsl_mu.c fsl_pmu.c fsl_rgpio.c fsl_s3mu.c fsl_soc_src.c fsl_trdc.c
    packages/nxp-imxrt-sdk-latest/MIMXRT1180/MIMXRT1189/iar/: startup_MIMXRT1189_cm33.s
    packages/nxp-imxrt-sdk-latest/MIMXRT1180/MIMXRT1189/: system_MIMXRT1189_cm33.c
  group MultiCore
    packages/nxp-imxrt-sdk-latest/MIMXRT1180/multicore/mcmgr/src/: mcmgr.c mcmgr_internal_core_api_imxrt1180.c mcmgr_mu_internal.c
  group xip
    xip/: evkmimxrt1180_flexspi_nor_config.c fsl_flexspi_nor_boot.c
