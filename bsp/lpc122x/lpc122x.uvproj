# Keil uVision project lpc122x.uvproj, settings and files
target RT-Thread LPC122x (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: lpc122x +hex
  c flags: Optim=2
  c include: .;..\..\include;..\..\libcpu\arm\lpc122x;..\..\examples\kernel
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group Startup
    ./: application.c board.c startup.c board.h rtconfig.h uart.c
  group Kernel
    ../../src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c module.c object.c rtm.c scheduler.c slab.c thread.c timer.c
  group LPC122x
    ../../libcpu/arm/lpc122x/: cpu.c fault.c interrupt.c stack.c context_rvds.S fault_rvds.S start_rvds.S
    ../../examples/kernel/: tc_comm.c
  group CMSIS
    ../../libcpu/arm/lpc122x/CMSIS/: system_LPC122x.c core_cm0.c
