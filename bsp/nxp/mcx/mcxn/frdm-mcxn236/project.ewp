# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MCXN236 NXP MCXN236
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 61
  General.FPU2: 6
  ICCARM.CCDefines: CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; DEBUG; CPU_MCXN236VDF; __RTTHREAD__; __RT_IPC_SOURCE__; __RT_KERNEL_SOURCE__
  ICCARM.CCIncludePath2: ..\libraries\drivers\config; ..\..\..\..\..\components\libc\posix\io\epoll; ..\..\..\..\..\components\libc\posix\io\poll; ..\..\..\..\..\components\libc\posix\ipc; applications; ..\..\..\..\..\components\utilities\ulog; ..\..\..\..\..\components\drivers\include; ..\libraries\MCXN236\MCXN236\drivers; ..\..\..\..\..\libcpu\arm\cortex-m33; ..\libraries\MCXN236\MCXN236; ..\..\..\..\..\include; ..\..\..\..\..\components\libc\posix\io\eventfd; ..\..\..\..\..\components\libc\compilers\common\extension; ..\..\..\..\..\components\libc\compilers\common\include; ..\libraries\drivers; ..\..\..\..\..\components\libc\compilers\common\extension\fcntl\octal; ..\..\..\..\..\components\finsh; ..\..\..\..\..\libcpu\arm\common; board; board\MCUX_Config\board; ..\libraries\CMSIS\Core\Include; .
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: template.out
  ILINK.IlinkIcfFile: board\linker_scripts\MCXN236_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; DEBUG; CPU_MCXN236VDF; __RTTHREAD__; __RT_IPC_SOURCE__; __RT_KERNEL_SOURCE__
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: uart_sample.c wdt_sample.c main.c
  group Compiler
    ../../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../../../components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
  group DeviceDrivers
    ../../../../../components/drivers/core/: device.c
    ../../../../../components/drivers/clock_time/: clock_timer.c
    ../../../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../../components/drivers/pin/: pin.c
    ../../../../../components/drivers/serial/: serial.c
    ../../../../../components/drivers/watchdog/: watchdog.c
  group Drivers
    board/MCUX_Config/board/: clock_config.c pin_mux.c
    board/: board.c
    ../libraries/drivers/: drv_pin.c drv_uart.c drv_wdt.c
  group Finsh
    ../../../../../components/finsh/: msh.c cmd.c shell.c msh_parse.c
  group Kernel
    ../../../../../src/: clock.c components.c cpu_up.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
    ../../../../../src/klibc/: kstdio.c kstring.c
  group libcpu
    ../../../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../../../libcpu/arm/cortex-m33/: context_iar.S cpuport.c syscall_iar.S trustzone.c
  group Libraries
    ../libraries/MCXN236/MCXN236/drivers/: fsl_flexio_spi.c fsl_lpspi_edma.c fsl_lpi2c.c fsl_gpio.c fsl_flexio_spi_edma.c fsl_flexio.c fsl_flexio_uart.c fsl_lptmr.c fsl_common_arm.c fsl_lpuart.c fsl_wwdt.c fsl_cache_lpcac.c fsl_ewm.c fsl_clock.c fsl_lpadc.c fsl_reset.c fsl_i3c_edma.c fsl_irtc.c fsl_flexio_mculcd_edma.c fsl_ctimer.c fsl_lpi2c_edma.c fsl_freqme.c fsl_spc.c fsl_lpflexcomm.c fsl_erm.c fsl_common.c fsl_evtg.c fsl_flexio_mculcd.c fsl_flexcan_edma.c fsl_mrt.c fsl_vref.c fsl_edma.c fsl_flexcan.c fsl_cmc.c fsl_eim.c fsl_edma_soc.c fsl_crc.c fsl_flexio_i2c_master.c fsl_flexio_uart_edma.c fsl_i3c.c fsl_lpspi.c fsl_cdog.c
    ../libraries/MCXN236/MCXN236/: system_MCXN236.c
    ../libraries/MCXN236/MCXN236/iar/: startup_MCXN236.s
  group Utilities
    ../../../../../components/utilities/ulog/backend/: console_be.c
    ../../../../../components/utilities/ulog/: ulog.c
