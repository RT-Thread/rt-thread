# Keil uVision project project.uvprojx, settings and files
target rtthread-lpc55s6x (6120000::V6.12::.\ARMCLANG)
  device: LPC55S69JBD100:cm33_core0 NXP
  pack: NXP.LPC55S69_DFP.1.0.0
  cpu: IRAM(0x20000000,0x044000) IRAM2(0x04000000,0x8000) IROM(0x00000000,0x098000) XRAM(0x40100000,0x4000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: rtthread-lpc55s6x
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=3
  c define: CPU_LPC55S69JBD100_cm33_core0, RT_USING_ARM_LIBC, __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND
  c misc: --target=arm-arm-none-eabi
  c include: ..\lpc55s69_nxp_evk\applications;..\..\..\libcpu\arm\common;..\..\..\libcpu\arm\cortex-m4;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\spi;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\lpc55s69_nxp_evk\board;..\lpc55s69_nxp_evk\board\MCUX_Config\board;..\Libraries\drivers;..\Libraries\drivers\config;..\..\..\components\dfs\include;..\..\..\components\dfs\filesystems\devfs;..\..\..\components\finsh;.;..\..\..\include;..\..\..\components\libc\compilers\armlibc;..\..\..\components\libc\compilers\common;..\..\..\components\libc\compilers\common\nogcc;..\Libraries\LPC55S6X\CMSIS\Include;..\Libraries\LPC55S6X\components\codec;..\Libraries\LPC55S6X\LPC55S6X;..\Libraries\LPC55S6X\LPC55S6X\drivers;..\Libraries\LPC55S6X\middleware\sdmmc\inc;..\Libraries\LPC55S6X\middleware\sdmmc\port;..\..\..\examples\utest\testcases\kernel
  memory RVCT4: ROM 0x0 size 0x98000
  memory RVCT6: RAM 0x40100000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x44000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: ..\lpc55s69_nxp_evk\board\linker_scripts\LPC55S69_cm33_core0_flash_ns_mdk.scf
  group Applications
    ../lpc55s69_nxp_evk/applications/: main.c
  group CPU
    ../../../libcpu/arm/common/: div0.c showmem.c backtrace.c
    ../../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../../components/drivers/hwtimer/: hwtimer.c
    ../../../components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    ../../../components/drivers/misc/: adc.c rt_drv_pwm.c pin.c
    ../../../components/drivers/rtc/: rtc.c
    ../../../components/drivers/sdio/: mmc.c sd.c block_dev.c sdio.c mmcsd_core.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/spi/: spi_core.c spi_dev.c
    ../../../components/drivers/src/: ringblk_buf.c pipe.c ringbuffer.c completion.c dataqueue.c workqueue.c waitqueue.c
  group Drivers
    ../lpc55s69_nxp_evk/board/MCUX_Config/board/: pin_mux.c clock_config.c
    ../lpc55s69_nxp_evk/board/: board.c
    ../Libraries/drivers/: drv_led.c drv_uart.c drv_spi.c drv_adc.c drv_pin.c drv_i2c.c drv_sd.c drv_mma8562.c drv_key.c drv_rtc.c drv_pwm.c drv_hwtimer.c
  group Filesystem
    ../../../components/dfs/src/: dfs_posix.c dfs_poll.c dfs_file.c dfs.c dfs_fs.c dfs_select.c
    ../../../components/dfs/filesystems/devfs/: devfs.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c msh_file.c cmd.c
  group Kernel
    ../../../src/: scheduler.c device.c object.c thread.c idle.c components.c irq.c timer.c clock.c ipc.c kservice.c mem.c mempool.c
  group libc
    ../../../components/libc/compilers/armlibc/: libc.c mem_std.c syscalls.c stdio.c
    ../../../components/libc/compilers/common/: unistd.c delay.c time.c stdlib.c
  group Libraries
    ../Libraries/LPC55S6X/LPC55S6X/drivers/: fsl_hashcrypt.c fsl_usart_dma.c fsl_spi_dma.c fsl_cmp.c fsl_utick.c fsl_power.c fsl_i2s_dma.c fsl_gpio.c fsl_casper.c fsl_clock.c fsl_wwdt.c fsl_reset.c fsl_sctimer.c fsl_common.c fsl_rtc.c fsl_crc.c fsl_sdif.c fsl_plu.c fsl_mrt.c fsl_i2s.c fsl_spi.c fsl_ctimer.c fsl_gint.c fsl_dma.c fsl_sysctl.c fsl_flexcomm.c fsl_pint.c fsl_powerquad_basic.c fsl_usart.c fsl_puf.c fsl_rng.c fsl_lpadc.c fsl_inputmux.c fsl_i2c_dma.c fsl_prince.c fsl_i2c.c fsl_anactrl.c fsl_iap.c fsl_ostimer.c
    ../Libraries/LPC55S6X/middleware/sdmmc/port/sdif/rt_thread/: fsl_sdmmc_host.c fsl_sdmmc_event.c
    ../Libraries/LPC55S6X/middleware/sdmmc/src/: fsl_sd.c fsl_sdmmc_common.c
    ../Libraries/LPC55S6X/LPC55S6X/arm/: startup_LPC55S69_cm33_core0.s keil_lib_power_cm33_core0.lib
    ../Libraries/LPC55S6X/LPC55S6X/: system_LPC55S69_cm33_core0.c
