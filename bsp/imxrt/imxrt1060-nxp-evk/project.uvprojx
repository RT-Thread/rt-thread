# Keil uVision project project.uvprojx, settings and files
target rtthread (6160000::V6.16::ARMCLANG)
  device: MIMXRT1062DVL6A NXP
  pack: NXP.MIMXRT1062_DFP.14.0.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x00000000,0x020000) IROM(0x00200000,0x020000) XRAM(0x20280000,0x040000) XRAM2(0x20200000,0x080000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rtthread
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: XIP_BOOT_HEADER_DCD_ENABLE=1, SKIP_SYSCLK_INIT, __FPU_PRESENT=1, __CLK_TCK=RT_TICK_PER_SECOND, __RTTHREAD__, FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1, DATA_SECTION_IS_CACHEABLE=1, XIP_BOOT_HEADER_ENABLE=1, FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1, CPU_MIMXRT1062DVL6A, XIP_EXTERNAL_FLASH=1, EVK_MCIMXRM, RT_USING_ARM_LIBC
  c misc: -fno-common -fdata-sections -ffreestanding -fno-builtin -mthumb
  c include: applications;..\..\..\components\libc\compilers\common;..\..\..\components\libc\compilers\common\extension;..\..\..\libcpu\arm\common;..\..\..\libcpu\arm\cortex-m7;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;board;board\MCUX_Config;board\ports;..\libraries\drivers;..\libraries\drivers\config;..\..\..\components\finsh;.;..\..\..\include;..\libraries\MIMXRT1060\CMSIS\Include;..\libraries\MIMXRT1060\MIMXRT1060;..\libraries\MIMXRT1060\MIMXRT1060\drivers;..\libraries\peripherals;packages\LVGL-v8.2.0\src;packages\LVGL-v8.2.0\src\core;packages\LVGL-v8.2.0\src\draw;packages\LVGL-v8.2.0\src\extra;packages\LVGL-v8.2.0\src\font;packages\LVGL-v8.2.0\src\gpu;packages\LVGL-v8.2.0\src\hal;packages\LVGL-v8.2.0\src\misc;packages\LVGL-v8.2.0\src\widgets;packages\LVGL-v8.2.0\src\draw\nxp_pxp;packages\LVGL-v8.2.0\src\draw\nxp_vglite;packages\LVGL-v8.2.0\src\draw\sdl;packages\LVGL-v8.2.0\src\draw\stm32_dma2d;packages\LVGL-v8.2.0\src\draw\sw;packages\LVGL-v8.2.0\src\extra\layouts;packages\LVGL-v8.2.0\src\extra\libs;packages\LVGL-v8.2.0\src\extra\others;packages\LVGL-v8.2.0\src\extra\themes;packages\LVGL-v8.2.0\src\extra\widgets;packages\LVGL-v8.2.0\src\extra\layouts\flex;packages\LVGL-v8.2.0\src\extra\layouts\grid;packages\LVGL-v8.2.0\src\extra\libs\bmp;packages\LVGL-v8.2.0\src\extra\libs\ffmpeg;packages\LVGL-v8.2.0\src\extra\libs\freetype;packages\LVGL-v8.2.0\src\extra\libs\fsdrv;packages\LVGL-v8.2.0\src\extra\libs\gif;packages\LVGL-v8.2.0\src\extra\libs\png;packages\LVGL-v8.2.0\src\extra\libs\qrcode;packages\LVGL-v8.2.0\src\extra\libs\rlottie;packages\LVGL-v8.2.0\src\extra\libs\sjpg;packages\LVGL-v8.2.0\src\extra\others\gridnav;packages\LVGL-v8.2.0\src\extra\others\monkey;packages\LVGL-v8.2.0\src\extra\others\snapshot;packages\LVGL-v8.2.0\src\extra\themes\basic;packages\LVGL-v8.2.0\src\extra\themes\default;packages\LVGL-v8.2.0\src\extra\themes\mono;packages\LVGL-v8.2.0\src\extra\widgets\animimg;packages\LVGL-v8.2.0\src\extra\widgets\calendar;packages\LVGL-v8.2.0\src\extra\widgets\chart;packages\LVGL-v8.2.0\src\extra\widgets\colorwheel;packages\LVGL-v8.2.0\src\extra\widgets\imgbtn;packages\LVGL-v8.2.0\src\extra\widgets\keyboard;packages\LVGL-v8.2.0\src\extra\widgets\led;packages\LVGL-v8.2.0\src\extra\widgets\list;packages\LVGL-v8.2.0\src\extra\widgets\menu;packages\LVGL-v8.2.0\src\extra\widgets\meter;packages\LVGL-v8.2.0\src\extra\widgets\msgbox;packages\LVGL-v8.2.0\src\extra\widgets\span;packages\LVGL-v8.2.0\src\extra\widgets\spinbox;packages\LVGL-v8.2.0\src\extra\widgets\spinner;packages\LVGL-v8.2.0\src\extra\widgets\tabview;packages\LVGL-v8.2.0\src\extra\widgets\tileview;packages\LVGL-v8.2.0\src\extra\widgets\win;applications\lvgl;packages\LVGL-v8.2.0\env_support\rt-thread;..\..\..\components\libc\posix\io\poll;..\..\..\components\libc\posix\io\stdio;..\..\..\components\libc\posix\ipc;xip
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT4: ROM 0x200000 size 0x20000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: .\board\linker_scripts\link.sct
  link misc: --keep=*(.boot_hdr.ivt)--keep=*(.boot_hdr.boot_data)--keep=*(.boot_hdr.dcd_data)--keep=*(.boot_hdr.conf)--entry=Reset_Handler --predefine="-DXIP_BOOT_HEADER_ENABLE=1"
  group Applications
    applications/: main.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscalls.c syscall_mem.c
    ../../../components/libc/compilers/common/: time.c stdlib.c
  group CPU
    ../../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m7/: context_rvds.S cpu_cache.c cpuport.c
  group DeviceDrivers
    ../../../components/drivers/cputime/: cputime.c
    ../../../components/drivers/ipc/: ringblk_buf.c pipe.c completion.c ringbuffer.c dataqueue.c workqueue.c waitqueue.c
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/serial/: serial.c
  group Drivers
    board/MCUX_Config/: dcd.c pin_mux.c clock_config.c
    board/: board.c
    ../libraries/drivers/: drv_lcd.c drv_gpio.c drv_uart.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c cmd.c
  group Kernel
    ../../../src/: memheap.c device.c thread.c idle.c components.c ipc.c clock.c irq.c object.c kservice.c scheduler.c timer.c mempool.c
  group Libraries
    ../libraries/MIMXRT1060/MIMXRT1060/drivers/: fsl_lpuart.c fsl_xbara.c fsl_clock.c fsl_pxp.c fsl_common.c fsl_gpio.c fsl_cache.c fsl_xbarb.c fsl_elcdif.c
    ../libraries/MIMXRT1060/MIMXRT1060/: system_MIMXRT1062.c
    ../libraries/MIMXRT1060/MIMXRT1060/arm/: startup_MIMXRT1062.s
  group LVGL
    packages/LVGL-v8.2.0/src/widgets/: lv_checkbox.c lv_canvas.c lv_btn.c lv_table.c lv_line.c lv_arc.c lv_dropdown.c lv_img.c lv_objx_templ.c lv_bar.c lv_roller.c lv_label.c lv_btnmatrix.c lv_slider.c lv_textarea.c lv_switch.c
    packages/LVGL-v8.2.0/src/draw/sw/: lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_arc.c lv_draw_sw_polygon.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw.c lv_draw_sw_rect.c
    packages/LVGL-v8.2.0/src/extra/widgets/span/: lv_span.c
    packages/LVGL-v8.2.0/src/extra/others/gridnav/: lv_gridnav.c
    packages/LVGL-v8.2.0/src/font/: lv_font_unscii_16.c lv_font_montserrat_28.c lv_font_montserrat_10.c lv_font_montserrat_30.c lv_font_montserrat_46.c lv_font_montserrat_38.c lv_font_dejavu_16_persian_hebrew.c lv_font_unscii_8.c lv_font_montserrat_12.c lv_font_montserrat_36.c lv_font_montserrat_12_subpx.c lv_font_montserrat_24.c lv_font_montserrat_16.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_44.c lv_font_montserrat_34.c lv_font_montserrat_28_compressed.c lv_font_montserrat_32.c lv_font_montserrat_48.c lv_font_montserrat_42.c lv_font_montserrat_14.c lv_font_montserrat_8.c lv_font.c lv_font_montserrat_18.c lv_font_loader.c lv_font_simsun_16_cjk.c lv_font_fmt_txt.c lv_font_montserrat_40.c lv_font_montserrat_26.c
    packages/LVGL-v8.2.0/src/misc/: lv_timer.c lv_tlsf.c lv_txt_ap.c lv_area.c lv_async.c lv_bidi.c lv_utils.c lv_anim_timeline.c lv_log.c lv_printf.c lv_lru.c lv_templ.c lv_ll.c lv_gc.c lv_fs.c lv_mem.c lv_math.c lv_color.c lv_anim.c lv_txt.c lv_style.c lv_style_gen.c
    packages/LVGL-v8.2.0/src/extra/widgets/list/: lv_list.c
    packages/LVGL-v8.2.0/src/extra/widgets/chart/: lv_chart.c
    packages/LVGL-v8.2.0/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    packages/LVGL-v8.2.0/src/core/: lv_obj_pos.c lv_obj_style.c lv_event.c lv_group.c lv_obj.c lv_refr.c lv_obj_scroll.c lv_obj_tree.c lv_indev.c lv_theme.c lv_indev_scroll.c lv_disp.c lv_obj_class.c lv_obj_style_gen.c lv_obj_draw.c
    packages/LVGL-v8.2.0/src/draw/nxp_pxp/: lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp_osa.c
    packages/LVGL-v8.2.0/src/extra/libs/png/: lodepng.c lv_png.c
    packages/LVGL-v8.2.0/src/draw/: lv_draw.c lv_draw_label.c lv_draw_img.c lv_img_buf.c lv_draw_mask.c lv_draw_triangle.c lv_img_cache.c lv_draw_line.c lv_img_decoder.c lv_draw_rect.c lv_draw_arc.c
    packages/LVGL-v8.2.0/src/extra/widgets/calendar/: lv_calendar_header_arrow.c lv_calendar_header_dropdown.c lv_calendar.c
    packages/LVGL-v8.2.0/src/draw/sdl/: lv_draw_sdl_mask.c lv_draw_sdl_img.c lv_draw_sdl_bg.c lv_draw_sdl_polygon.c lv_draw_sdl_label.c lv_draw_sdl_arc.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_rect.c lv_draw_sdl_line.c lv_draw_sdl_utils.c lv_draw_sdl.c lv_draw_sdl_composite.c
    packages/LVGL-v8.2.0/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    packages/LVGL-v8.2.0/src/extra/themes/default/: lv_theme_default.c
    packages/LVGL-v8.2.0/src/extra/layouts/grid/: lv_grid.c
    packages/LVGL-v8.2.0/src/extra/themes/mono/: lv_theme_mono.c
    packages/LVGL-v8.2.0/src/extra/libs/qrcode/: qrcodegen.c lv_qrcode.c
    packages/LVGL-v8.2.0/src/extra/widgets/win/: lv_win.c
    packages/LVGL-v8.2.0/src/extra/widgets/imgbtn/: lv_imgbtn.c
    packages/LVGL-v8.2.0/src/hal/: lv_hal_disp.c lv_hal_tick.c lv_hal_indev.c
    packages/LVGL-v8.2.0/src/extra/widgets/meter/: lv_meter.c
    packages/LVGL-v8.2.0/src/extra/others/snapshot/: lv_snapshot.c
    packages/LVGL-v8.2.0/src/extra/widgets/msgbox/: lv_msgbox.c
    packages/LVGL-v8.2.0/src/extra/libs/fsdrv/: lv_fs_win32.c lv_fs_stdio.c lv_fs_fatfs.c lv_fs_posix.c
    packages/LVGL-v8.2.0/src/extra/widgets/menu/: lv_menu.c
    packages/LVGL-v8.2.0/src/extra/libs/freetype/: lv_freetype.c
    packages/LVGL-v8.2.0/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    packages/LVGL-v8.2.0/src/extra/libs/gif/: gifdec.c lv_gif.c
    packages/LVGL-v8.2.0/src/extra/widgets/animimg/: lv_animimg.c
    packages/LVGL-v8.2.0/src/extra/widgets/spinner/: lv_spinner.c
    packages/LVGL-v8.2.0/src/extra/widgets/led/: lv_led.c
    packages/LVGL-v8.2.0/src/extra/libs/bmp/: lv_bmp.c
    packages/LVGL-v8.2.0/src/draw/nxp_vglite/: lv_gpu_nxp_vglite.c
    packages/LVGL-v8.2.0/src/extra/: lv_extra.c
    packages/LVGL-v8.2.0/src/extra/widgets/tabview/: lv_tabview.c
    packages/LVGL-v8.2.0/src/extra/widgets/keyboard/: lv_keyboard.c
    packages/LVGL-v8.2.0/src/extra/libs/rlottie/: lv_rlottie.c
    packages/LVGL-v8.2.0/src/extra/widgets/colorwheel/: lv_colorwheel.c
    packages/LVGL-v8.2.0/src/extra/layouts/flex/: lv_flex.c
    packages/LVGL-v8.2.0/src/extra/widgets/tileview/: lv_tileview.c
    packages/LVGL-v8.2.0/src/extra/widgets/spinbox/: lv_spinbox.c
    packages/LVGL-v8.2.0/src/extra/themes/basic/: lv_theme_basic.c
    packages/LVGL-v8.2.0/src/extra/others/monkey/: lv_monkey.c
  group LVGL-demo
    packages/lv_music_demo-v0.2.0/assets/: img_lv_demo_rtt_music_btn_rnd.c img_lv_demo_rtt_music_icon_2.c img_lv_demo_rtt_music_btn_list_play.c img_lv_demo_rtt_music_list_border.c img_lv_demo_rtt_music_btn_loop.c img_lv_demo_rtt_music_btn_prev.c img_lv_demo_rtt_music_corner_right.c img_lv_demo_rtt_music_logo.c img_lv_demo_rtt_music_btn_pause.c img_lv_demo_rtt_music_cover_3.c img_lv_demo_rtt_music_btn_next.c img_lv_demo_rtt_music_cover_1.c img_lv_demo_rtt_music_icon_3.c img_lv_demo_rtt_music_icon_4.c img_lv_demo_rtt_music_btn_list_pause.c img_lv_demo_rtt_music_icon_1.c img_lv_demo_rtt_music_corner_left.c img_lv_demo_rtt_music_btn_play.c img_lv_demo_rtt_music_wave_bottom.c img_lv_demo_rtt_music_wave_top.c img_lv_demo_rtt_music_cover_2.c img_lv_demo_rtt_music_slider_knob.c
    packages/lv_music_demo-v0.2.0/: lv_demo_rtt_music.c lv_demo_rtt_music_main.c lv_demo_rtt_music_list.c
  group LVGL-port
    applications/lvgl/: lv_port_indev.c lv_demo.c lv_port_disp.c
    packages/LVGL-v8.2.0/env_support/rt-thread/: lv_rt_thread_port.c
  group xip
    xip/: evkbmimxrt1060_flexspi_nor_config.c fsl_flexspi_nor_boot.c
