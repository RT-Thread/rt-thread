<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
<batchBuild><batchDefinition><name>all</name><member><project>KsdkPlatformLib_KL46Z4</project><configuration>Debug</configuration></member><member><project>rt_thread_demo_frdmkl46z</project><configuration>Debug</configuration></member><member><project>KsdkPlatformLib_KL46Z4</project><configuration>Release</configuration></member><member><project>rt_thread_demo_frdmkl46z</project><configuration>Release</configuration></member></batchDefinition><batchDefinition><name>Debug</name><member><project>KsdkPlatformLib_KL46Z4</project><configuration>Debug</configuration></member><member><project>rt_thread_demo_frdmkl46z</project><configuration>Debug</configuration></member></batchDefinition><batchDefinition><name>Release</name><member><project>KsdkPlatformLib_KL46Z4</project><configuration>Release</configuration></member><member><project>rt_thread_demo_frdmkl46z</project><configuration>Release</configuration></member></batchDefinition></batchBuild>
<project><path>$WS_DIR$/../../../../lib/ksdk_platform_lib/KsdkPlatformLib/iar/KsdkPlatformLib_KL46Z4.ewp</path></project><project><path>$WS_DIR$/rt_thread_demo_frdmkl46z.ewp</path></project></workspace>
