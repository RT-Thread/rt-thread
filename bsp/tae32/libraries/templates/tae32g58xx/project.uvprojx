# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TAE32G5800 Tai-Action
  pack: Tai-Action.TAE32G58xx_DFP.1.3.0
  cpu: IRAM(0x20000000,0x10000) IRAM2(0x20010000,0x10000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __STDC_LIMIT_MACROS, __CLK_TCK=RT_TICK_PER_SECOND, RT_USING_LIBC, __RTTHREAD__, RT_USING_ARMLIBC, TAE32G5800, USE_STDPERIPH_DRIVER
  c include: ..\..\..\include;.;..\libraries\TAE32G58xx_Firmware_Library\TAE32G58xx_Device\Inc;..\..\..\components\libc\posix\io\eventfd;..\libraries\TAE32G58xx_Firmware_Library\TAE32G58xx_Driver\Inc;..\libraries\tae32_drivers;..\..\..\components\drivers\include;..\..\..\components\drivers\phy;..\..\..\components\drivers\smp_call;..\..\..\components\libc\posix\ipc;..\..\..\libcpu\arm\common;..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\components\libc\posix\io\epoll;..\..\..\components\libc\compilers\common\extension;..\libraries\tae32_drivers\config;board;..\..\..\components\drivers\include;..\..\..\components\libc\posix\io\poll;..\..\..\components\libc\compilers\common\include;..\..\..\libcpu\arm\cortex-m4;applications;..\libraries\TAE32G58xx_Firmware_Library\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x20010000 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
  group Drivers
    ../libraries/TAE32G58xx_Firmware_Library/TAE32G58xx_Device/Src/: startup_tae32g58xx.c
    board/: board.c tae32g58xx_ll_msp.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    ../../../src/klibc/: kerrno.c rt_vsscanf.c rt_vsnprintf_tiny.c kstring.c kstdio.c
  group libcpu
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group Libraries
    ../libraries/TAE32G58xx_Firmware_Library/TAE32G58xx_Device/Src/: system_tae32g58xx.c
    ../libraries/TAE32G58xx_Firmware_Library/TAE32G58xx_Driver/Src/: tae32g58xx_ll_rcu.c tae32g58xx_ll_gpio.c tae32g58xx_ll.c tae32g58xx_ll_cortex.c tae32g58xx_ll_sysctrl.c
