# Keil uVision project template.uvproj, settings and files
target rt-thread (ARM-ADS)
  device: AT32F456ZET7 ArteryTek
  cpu: IRAM(0x20000000-0x20023FFF) IROM(0x08000000-0x0807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x24000
  scatter file: .\board\linker_scripts\link.sct
