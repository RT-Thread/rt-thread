<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\STM32MP157-DK1.ewp</path>
  </project>
  <batchBuild />
</workspace>
