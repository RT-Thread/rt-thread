# Keil uVision project project.uvproj, settings and files
target rt-thread_lm4f232 (ARM-ADS)
  device: LM4F232H5QD Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: project
  c flags: Optim=1 OneElfS=1
  c define: PART_LM4F232H5QD
  c include: .;..\..\include;applications;.;drivers;Libraries;..\..\libcpu\arm\common;..\..\libcpu\arm\cortex-m4;..\..\components\finsh;..\..\components\libc\compilers\common
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Kernel
    ../../src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group Applications
    applications/: application.c startup.c
  group Drivers
    drivers/: board.c serial.c
  group Libraries
    Libraries/driverlib/: adc.c can.c comp.c cpu.c eeprom.c epi.c ethernet.c fan.c flash.c fpu.c gpio.c hibernate.c i2c.c i2s.c interrupt.c lpc.c mpu.c peci.c pwm.c qei.c ssi.c sysctl.c sysexc.c systick.c timer.c uart.c udma.c usb.c watchdog.c
    Libraries/startup/arm/: start_rvds.S
  group cpu
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
  group finsh
    ../../components/finsh/: shell.c cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_var.c finsh_vm.c finsh_token.c
