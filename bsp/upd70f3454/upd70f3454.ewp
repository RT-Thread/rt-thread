# IAR project upd70f3454.ewp, settings and files
configuration Debug (V850, debug)
  General.GMemoryModel: 0
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl85nn1.h
  General.GHeapSize: 4096
  General.GDeviceSelect: 70F3454 V850E - uPD70F3454
  ICCV850.CCIncludePath2: ; applilet3_src\; ..\..\include\; ..\..\components\finsh
  ICCV850.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCV850.CCOptLevel: 1
  ICCV850.CCOptStrategy: 0
  AV850.ADefines: CODE_MODEL_NORMAL; DATA_MODEL_TINY
  AV850.OAStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: lnk70f3454.xcl
  XLINK.XlinkStackSize: 1
configuration Release (V850)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  General.GDeviceSelect: 70F3746 V850ES- uPD70F3746
  ICCV850.CCDefines: NDEBUG
  ICCV850.CCOptLevel: 3
  ICCV850.CCOptStrategy: 1
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: application.c board.c cstartup.s85 startup.c uart.c
    applilet3_src/: CG_port.c CG_port_user.c CG_system.c CG_system_user.c CG_systeminit.c CG_timer.c CG_timer_user.c
  group finsh
    ../../components/finsh/: cmd.c finsh.h finsh_compiler.c finsh_error.c finsh_error.h finsh_heap.c finsh_heap.h finsh_init.c finsh_node.c finsh_node.h finsh_ops.c finsh_ops.h finsh_parser.c finsh_parser.h finsh_token.c finsh_token.h finsh_var.c finsh_var.h finsh_vm.c finsh_vm.h shell.c shell.h symbol.c
  group include
    ../../include/: rtdef.h rthw.h rtm.h rtthread.h
  group kernel
    ../../src/: clock.c device.c idle.c ipc.c irq.c kservice.c kservice.h mem.c mempool.c module.c module.h object.c rtm.c scheduler.c slab.c thread.c timer.c
  group libcpu
    ../../libcpu/v850/: context.asm interrupt.c stack.c
