# Keil uVision project project.uvprojx, settings and files
target rt-thread_stm32h7xx (ARM-ADS)
  device: STM32H743ZITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2407FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: rtthread-stm32h7xx
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: USE_HAL_DRIVER, RT_USING_ARM_LIBC, STM32H743xx
  c include: applications;.;drivers;Libraries\CMSIS\Device\ST\STM32H7xx\Include;Libraries\CMSIS\Include;Libraries\STM32H7xx_HAL_Driver\Inc;D:/rt-thread-master/rt-thread-master-20170825/include;D:/rt-thread-master/rt-thread-master-20170825/libcpu/arm/cortex-m7;D:/rt-thread-master/rt-thread-master-20170825/libcpu/arm/common;D:/rt-thread-master/rt-thread-master-20170825/components/drivers/include;D:/rt-thread-master/rt-thread-master-20170825/components/drivers/include;D:/rt-thread-master/rt-thread-master-20170825/components/finsh;D:/rt-thread-master/rt-thread-master-20170825/components/libc/armlibc;D:/rt-thread-master/rt-thread-master-20170825/components/libc/pthreads;D:/rt-thread-master/rt-thread-master-20170825/components/net/lwip-1.4.1/src;D:/rt-thread-master/rt-thread-master-20170825/components/net/lwip-1.4.1/src/include;D:/rt-thread-master/rt-thread-master-20170825/components/net/lwip-1.4.1/src/include/ipv4;D:/rt-thread-master/rt-thread-master-20170825/components/net/lwip-1.4.1/src/arch/include;D:/rt-thread-master/rt-thread-master-20170825/components/net/lwip-1.4.1/src/include/netif
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20010000 size 0x40000
  memory RVCT10: RAM 0x20000000 size 0x10000
  link misc: --keep *.o(.rti_fn.*)   --keep *.o(FSymTab) --keep *.o(VSymTab)
  group Applications
    applications/: main.c sram.c
  group Drivers
    drivers/: board.c drv_led.c drv_mpu.c drv_usart.c lan8742a.c stm32h7xx_it.c
  group CMSIS
    Libraries/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
    Libraries/CMSIS/Device/ST/STM32H7xx/Source/Templates/arm/: startup_stm32h743xx.s
  group STM32H7xx_HAL_Driver
    Libraries/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_cec.c stm32h7xx_hal_comp.c stm32h7xx_hal_cortex.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_cryp.c stm32h7xx_hal_cryp_ex.c stm32h7xx_hal_dac.c stm32h7xx_hal_dac_ex.c stm32h7xx_hal_dcmi.c stm32h7xx_hal_dfsdm.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_eth.c stm32h7xx_hal_eth_ex.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hash.c stm32h7xx_hal_hash_ex.c stm32h7xx_hal_hcd.c stm32h7xx_hal_hrtim.c stm32h7xx_hal_hsem.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_i2s.c stm32h7xx_hal_i2s_ex.c stm32h7xx_hal_irda.c stm32h7xx_hal_iwdg.c stm32h7xx_hal_jpeg.c stm32h7xx_hal_lptim.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_mdios.c stm32h7xx_hal_mdma.c stm32h7xx_hal_mmc.c stm32h7xx_hal_mmc_ex.c stm32h7xx_hal_nand.c stm32h7xx_hal_nor.c stm32h7xx_hal_opamp.c stm32h7xx_hal_opamp_ex.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_qspi.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_rng.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_sai.c stm32h7xx_hal_sai_ex.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_sdram.c stm32h7xx_hal_smartcard.c stm32h7xx_hal_smartcard_ex.c stm32h7xx_hal_smbus.c stm32h7xx_hal_spdifrx.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_sram.c stm32h7xx_hal_swpmi.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_usart.c stm32h7xx_hal_wwdg.c stm32h7xx_ll_fmc.c stm32h7xx_ll_sdmmc.c stm32h7xx_ll_usb.c
  group Kernel
    D:/rt-thread-master/rt-thread-master-20170825/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c thread.c timer.c
  group CORTEX-M7
    D:/rt-thread-master/rt-thread-master-20170825/libcpu/arm/cortex-m7/: cpuport.c context_rvds.S
    D:/rt-thread-master/rt-thread-master-20170825/libcpu/arm/common/: backtrace.c div0.c showmem.c
  group DeviceDrivers
    D:/rt-thread-master/rt-thread-master-20170825/components/drivers/serial/: serial.c
    D:/rt-thread-master/rt-thread-master-20170825/components/drivers/src/: completion.c dataqueue.c pipe.c portal.c ringbuffer.c workqueue.c
  group finsh
    D:/rt-thread-master/rt-thread-master-20170825/components/finsh/: shell.c symbol.c cmd.c msh.c msh_cmd.c msh_file.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_var.c finsh_vm.c finsh_token.c
  group libc
    D:/rt-thread-master/rt-thread-master-20170825/components/libc/armlibc/: libc_syms.c mem_std.c stubs.c
  group pthreads
    D:/rt-thread-master/rt-thread-master-20170825/components/libc/pthreads/: clock_time.c mqueue.c pthread.c pthread_attr.c pthread_barrier.c pthread_cond.c pthread_mutex.c pthread_rwlock.c pthread_spin.c pthread_tls.c sched.c semaphore.c
  group LwIP
    D:/rt-thread-master/rt-thread-master-20170825/components/net/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    D:/rt-thread-master/rt-thread-master-20170825/components/net/lwip-1.4.1/src/arch/: sys_arch.c
    D:/rt-thread-master/rt-thread-master-20170825/components/net/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    D:/rt-thread-master/rt-thread-master-20170825/components/net/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    D:/rt-thread-master/rt-thread-master-20170825/components/net/lwip-1.4.1/src/netif/: etharp.c ethernetif.c slipif.c
