# IAR project project.ewp, settings and files
configuration rtthread (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1062xxx6A NXP MIMXRT1062xxx6A
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; CPU_MIMXRT1062DVL6A; SKIP_SYSCLK_INIT; EVK_MCIMXRM; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; DATA_SECTION_IS_CACHEABLE=1; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=1; __RTTHREAD__; __RT_IPC_SOURCE__; __RT_KERNEL_SOURCE__
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: xip; ..\..\..\..\..\components\libc\posix\io\eventfd; ..\..\..\..\..\components\drivers\include; ..\..\..\..\..\include; ..\..\..\..\..\libcpu\arm\common; ..\..\..\..\..\components\libc\posix\io\poll; applications; board; ..\..\..\..\..\components\libc\compilers\common\include; ..\..\..\..\..\libcpu\arm\cortex-m7; ..\libraries\drivers; ..\libraries\MIMXRT1060\MIMXRT1060; ..\..\..\..\..\components\libc\compilers\common\extension; ..\..\..\..\..\components\libc\posix\io\epoll; ..\libraries\MIMXRT1060\CMSIS\Include; ..\..\..\..\..\components\drivers\phy; ..\..\..\..\..\components\finsh; ..\..\..\..\..\components\libc\posix\ipc; board\MCUX_Config; ..\libraries\MIMXRT1060\MIMXRT1060\drivers; .; ..\..\..\..\..\components\libc\compilers\common\extension\fcntl\octal; board\ports; ..\..\..\..\..\components\drivers\smp_call
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: template.srec
  ILINK.IlinkOutputFile: rtthread.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Applications
    applications/: mnt.c main.c
  group Compiler
    ../../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../../../components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
  group DeviceDrivers
    ../../../../../components/drivers/core/: device.c
    ../../../../../components/drivers/i2c/: dev_i2c_bit_ops.c dev_i2c_core.c dev_i2c_dev.c
    ../../../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../../components/drivers/phy/: phy.c
    ../../../../../components/drivers/pin/: dev_pin.c
    ../../../../../components/drivers/serial/: dev_serial.c
  group Drivers
    board/MCUX_Config/: clock_config.c dcd.c pin_mux.c
    board/: board.c
    ../libraries/drivers/: drv_common.c drv_gpio.c drv_uart.c
  group Finsh
    ../../../../../components/finsh/: cmd.c msh_parse.c msh.c shell.c
  group Kernel
    ../../../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    ../../../../../src/klibc/: rt_vsscanf.c kstring.c rt_vsnprintf_tiny.c kerrno.c kstdio.c
  group libcpu
    ../../../../../libcpu/arm/common/: div0.c showmem.c
    ../../../../../libcpu/arm/cortex-m7/: context_iar.S cpu_cache.c cpuport.c
  group Libraries
    ../libraries/MIMXRT1060/MIMXRT1060/drivers/: fsl_clock.c fsl_xbara.c fsl_os_abstraction_rtthread.c fsl_common.c fsl_cache.c generic_list.c fsl_gpio.c fsl_common_arm.c fsl_xbarb.c fsl_lpuart.c
    ../libraries/MIMXRT1060/MIMXRT1060/: system_MIMXRT1062.c
    ../libraries/MIMXRT1060/MIMXRT1060/iar/: startup_MIMXRT1062.s
  group xip
    xip/: fsl_flexspi_nor_boot.c evkmimxrt1060_flexspi_nor_config.c
