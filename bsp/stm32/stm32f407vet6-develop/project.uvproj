# Keil uVision project project.uvproj, settings and files
target rt-thread (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: RTT_U8G2, USE_HAL_DRIVER, STM32F407xx, __CLK_TCK=RT_TICK_PER_SECOND, __RTTHREAD__, RT_USING_ARM_LIBC
  c include: applications;.;..\..\..\components\cplusplus;..\..\..\libcpu\arm\common;..\..\..\libcpu\arm\cortex-m4;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\spi;..\..\..\components\drivers\include;..\..\..\components\drivers\include;board;board\CubeMX_Config\Inc;board\ports;..\libraries\HAL_Drivers;..\libraries\HAL_Drivers\config;..\..\..\components\finsh;.;..\..\..\include;..\..\..\components\libc\compilers\armlibc;..\..\..\components\libc\compilers\common;..\..\..\components\libc\compilers\common\nogcc;..\libraries\STM32F4xx_HAL\STM32F4xx_HAL_Driver\Inc;..\libraries\STM32F4xx_HAL\CMSIS\Device\ST\STM32F4xx\Include;..\libraries\STM32F4xx_HAL\CMSIS\Include;packages\u8g2-latest;packages\u8g2-latest\port;packages\u8g2-latest\src;..\..\..\examples\utest\testcases\kernel
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: PrintUTF8.cpp main.c
  group CPlusPlus
    ../../../components/cplusplus/: cxx_Thread.cpp cxx_Semaphore.cpp crt_init.c cxx_crt.cpp cxx_Mutex.cpp
  group CPU
    ../../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/spi/: spi_core.c spi_dev.c
    ../../../components/drivers/src/: ringblk_buf.c dataqueue.c workqueue.c ringbuffer.c pipe.c completion.c waitqueue.c
  group Drivers
    ../libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
    board/CubeMX_Config/Src/: stm32f4xx_hal_msp.c
    board/ports/: spi_oled_init.c
    board/: board.c
    ../libraries/HAL_Drivers/: drv_gpio.c drv_usart.c drv_common.c drv_spi.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c cmd.c
  group Kernel
    ../../../src/: timer.c mem.c clock.c kservice.c scheduler.c thread.c ipc.c device.c mempool.c irq.c components.c idle.c object.c
  group libc
    ../../../components/libc/compilers/armlibc/: mem_std.c libc.c syscalls.c
    ../../../components/libc/compilers/common/: stdlib.c time.c
  group Libraries
    ../libraries/STM32F4xx_HAL/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_uart.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_dma.c stm32f4xx_hal.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_usart.c stm32f4xx_hal_cec.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_crc.c stm32f4xx_hal_cortex.c stm32f4xx_hal_cryp.c stm32f4xx_hal_gpio.c
    ../libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group U8G2
    packages/u8g2-latest/src/: u8g2_polygon.c u8x8_d_uc1611.c u8x8_d_ls013b7dh03.c u8x8_d_ssd1318.c u8g2_circle.c u8x8_d_uc1610.c u8x8_d_ssd1326.c u8x8_d_pcf8814_hx1230.c u8x8_d_ssd1325.c u8g2_cleardisplay.c u8x8_d_sh1106_64x32.c u8x8_d_uc1601.c u8x8_d_ist3020.c u8x8_d_ssd1309.c u8x8_d_max7219.c u8g2_box.c u8x8_d_s1d15e06.c u8x8_d_ssd1306_128x64_noname.c u8x8_d_stdio.c u8g2_font.c u8x8_cad.c u8x8_d_ssd1320.c u8x8_d_st75320.c u8x8_d_ks0108.c u8x8_d_sh1108.c u8g2_buffer.c u8x8_d_uc1604.c u8x8_d_ssd1329.c u8x8_d_st75256.c u8g2_kerning.c u8x8_debounce.c u8x8_d_st7586s_ymc240160.c u8x8_d_sh1106_72x40.c u8g2_setup.c u8x8_byte.c u8x8_fonts.c u8x8_d_ssd1606_172x72.c u8x8_d_st7565.c u8g2_line.c u8x8_u16toa.c u8x8_u8toa.c u8x8_capture.c u8x8_d_sbn1661.c u8x8_d_ssd1306_48x64.c u8g2_ll_hvline.c u8x8_d_uc1701_dogs102.c u8x8_d_a2printer.c u8g2_selection_list.c u8x8_d_uc1701_mini12864.c u8x8_d_st7567.c u8x8_d_s1d15721.c u8x8_d_ssd1306_64x48.c u8x8_selection_list.c u8x8_setup.c u8x8_d_hd44102.c u8x8_d_ssd1306_96x16.c u8x8_d_st7511.c u8x8_d_ssd1306_64x32.c u8g2_d_memory.c u8x8_input_value.c u8log_u8g2.c u8g2_message.c u8x8_display.c u8x8_d_st7528.c u8x8_d_ssd1306_72x40.c u8g2_fonts.c u8x8_d_uc1617.c u8x8_d_st7586s_erc240160.c u8x8_d_ssd1305.c u8g2_bitmap.c u8x8_d_st7571.c u8x8_d_uc1608.c u8x8_d_pcf8812.c u8x8_gpio.c u8x8_d_st7586s_s028hn118a.c u8x8_d_ist7920.c u8x8_d_ssd1306_2040x16.c u8g2_input_value.c u8x8_d_uc1638.c u8x8_d_ssd1316.c u8log.c u8g2_hvline.c u8x8_message.c u8x8_d_ssd1327.c u8x8_d_st7588.c u8x8_d_ld7032_60x32.c u8x8_d_sh1107.c u8x8_d_ssd1317.c u8x8_d_il3820_296x128.c u8x8_d_lc7981.c u8x8_d_sh1122.c u8g2_intersection.c u8x8_d_t6963.c u8x8_d_ssd1607_200x200.c u8x8_d_st7920.c u8x8_d_sed1330.c u8x8_d_ssd1306_128x32.c u8x8_string.c u8x8_d_ssd1322.c u8x8_8x8.c u8x8_d_pcd8544_84x48.c u8g2_d_setup.c u8log_u8x8.c
    packages/u8g2-latest/port/: U8g2lib.cpp u8g2_port.c U8x8lib.cpp Print.cpp
    packages/u8g2-latest/examples/u8x8/: HelloWorld_8x8.cpp
