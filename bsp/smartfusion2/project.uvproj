# Keil uVision project project.uvproj, settings and files
target project (ARM-ADS)
  device: M2S010 Microsemi
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x0-0x3FFFF) CLOCK(20000000) CPUTYPE("Cortex-M3")
  output: rtthread +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 uC99=1
  c define: __CLK_TCK=RT_TICK_PER_SECOND, __STDC_LIMIT_MACROS, RT_USING_LIBC, RT_USING_ARMLIBC, __RTTHREAD__
  c include: ..\..\libcpu\arm\common;..\..\components\drivers\smp_call;libraries\sys_config;..\..\components\libc\compilers\common\extension;..\..\components\libc\posix\io\poll;..\..\components\libc\posix\io\eventfd;..\..\components\libc\posix\ipc;CMSIS;..\..\components\libc\compilers\common\extension\fcntl\octal;.;..\..\components\drivers\include;..\..\components\drivers\include;..\..\include;..\..\components\drivers\include;..\..\libcpu\arm\cortex-m3;..\..\components\drivers\include;drivers;..\..\components\drivers\include;applications;..\..\components\libc\compilers\common\include;..\..\components\libc\posix\io\epoll;board;..\..\components\drivers\phy;libraries\mss_gpio;..\..\components\finsh;libraries\mss_uart;..\..\components\drivers\include;..\..\components\net\utest
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\applications\link.sct
  group Applications
    applications/: main.c
    board/: board.c config.c
  group CMSIS
    CMSIS/: core_cm3.c system_m2sxxx.c
    CMSIS/startup_arm/: startup_m2sxxx.s
  group CPU
    ../../libcpu/arm/common/: div0.c showmem.c
    ../../libcpu/arm/cortex-m3/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../components/drivers/core/: device.c
    ../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../components/drivers/pin/: dev_pin.c
    ../../components/drivers/serial/: dev_serial.c
  group Drivers
    drivers/: drv_uart.c drv_gpio.c
  group Finsh
    ../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group Libc
    ../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
  group Libraries
    libraries/sys_config/: sys_config.c
    libraries/mss_gpio/: mss_gpio.c
    libraries/mss_uart/: mss_uart.c
