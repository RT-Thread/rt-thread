# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32G030C8Tx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, RT_USING_ARMLIBC, STM32G030xx, RT_USING_LIBC, __STDC_LIMIT_MACROS, __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND
  c include: applications;..\..\..\components\drivers\include;..\libraries\HAL_Drivers\CMSIS\Include;..\..\..\components\drivers\smp_call;..\..\..\components\libc\posix\io\eventfd;..\libraries\HAL_Drivers\drivers\config;..\..\..\components\drivers\include;..\..\..\libcpu\arm\common;..\..\..\components\drivers\include;..\..\..\components\libc\compilers\common\extension;..\..\..\components\finsh;..\libraries\HAL_Drivers;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\libc\posix\io\epoll;..\..\..\libcpu\arm\cortex-m0;..\..\..\components\libc\posix\ipc;board\CubeMX_Config\Inc;..\..\..\components\libc\posix\io\poll;..\..\..\components\drivers\phy;..\..\..\components\libc\compilers\common\include;..\libraries\STM32G0xx_HAL\STM32G0xx_HAL_Driver\Inc;..\..\..\include;..\libraries\STM32G0xx_HAL\CMSIS\Device\ST\STM32G0xx\Include;.;board;..\libraries\HAL_Drivers\drivers;..\..\..\components\libc\compilers\common\extension\fcntl\octal
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/pin/: dev_pin.c
    ../../../components/drivers/serial/: dev_serial.c
  group Drivers
    ../libraries/HAL_Drivers/drivers/: drv_gpio.c drv_usart.c
    ../libraries/HAL_Drivers/: drv_common.c
    ../libraries/STM32G0xx_HAL/CMSIS/Device/ST/STM32G0xx/Source/Templates/arm/: startup_stm32g030xx.s
    board/CubeMX_Config/Src/: stm32g0xx_hal_msp.c
    board/: board.c
  group Finsh
    ../../../components/finsh/: cmd.c msh_parse.c shell.c msh.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    ../../../src/klibc/: kstring.c kstdio.c kerrno.c
  group libcpu
    ../../../libcpu/arm/common/: div0.c showmem.c
    ../../../libcpu/arm/cortex-m0/: context_rvds.S cpuport.c
  group Libraries
    ../libraries/STM32G0xx_HAL/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal.c stm32g0xx_hal_usart_ex.c stm32g0xx_hal_flash.c stm32g0xx_hal_pwr.c stm32g0xx_hal_gpio.c stm32g0xx_hal_uart.c stm32g0xx_hal_uart_ex.c stm32g0xx_hal_cortex.c stm32g0xx_hal_rcc_ex.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_dma_ex.c stm32g0xx_hal_pwr_ex.c stm32g0xx_ll_usart.c stm32g0xx_hal_dma.c stm32g0xx_hal_cec.c stm32g0xx_hal_rcc.c
    ../libraries/STM32G0xx_HAL/CMSIS/Device/ST/STM32G0xx/Source/Templates/: system_stm32g0xx.c
