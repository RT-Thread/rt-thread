# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC1768 NXP LPC1768
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __RTTHREAD__
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\components\net\lwip-2.0.2\src; ..\..\include; CMSIS\CM3\DeviceSupport\NXP\LPC17xx; drivers; ..\..\components\net\lwip-2.0.2\src\include\ipv4; .; applications; ..\..\components\net\lwip-2.0.2\src\include\netif; ..\..\libcpu\arm\cortex-m3; CMSIS\CMSIS\Include; ..\..\libcpu\arm\common; ..\..\components\finsh; ..\..\components\net\lwip-2.0.2\src\include\posix; ..\..\components\net\lwip-2.0.2\src\arch\include; ..\..\components\net\lwip-2.0.2\src\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: project.srec
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: rtthread-lpc17xx.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; __RTTHREAD__
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: application.c platform.c startup.c
  group CMSIS
    CMSIS/CM3/DeviceSupport/NXP/LPC17xx/: system_LPC17xx.c
    CMSIS/CM3/DeviceSupport/NXP/LPC17xx/startup/iar/: startup_LPC17xx.s
  group CPU
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../libcpu/arm/cortex-m3/: cpuport.c context_iar.S
  group Drivers
    drivers/: board.c emac.c led.c spi.c uart.c
  group finsh
    ../../components/finsh/: shell.c cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_var.c finsh_vm.c finsh_token.c
  group Kernel
    ../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group lwIP
    ../../components/net/lwip-2.0.2/src/arch/: sys_arch.c
    ../../components/net/lwip-2.0.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../components/net/lwip-2.0.2/src/core/: def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../components/net/lwip-2.0.2/src/netif/: ethernet.c ethernetif.c lowpan6.c
    ../../components/net/lwip-2.0.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
