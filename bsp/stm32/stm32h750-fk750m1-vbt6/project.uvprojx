# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32H750VBTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) IROM2(0x08100000,0x00100000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: __CLK_TCK=RT_TICK_PER_SECOND, USE_HAL_DRIVER, RT_USING_ARMLIBC, __RTTHREAD__, RT_USING_LIBC, __STDC_LIMIT_MACROS, STM32H750xx
  c include: ..\..\..\components\libc\posix\io\poll;..\..\..\libcpu\arm\cortex-m7;..\libraries\STM32H7xx_HAL\CMSIS\Device\ST\STM32H7xx\Include;..\..\..\components\drivers\include;..\libraries\HAL_Drivers\drivers;..\..\..\components\libc\compilers\common\include;..\libraries\HAL_Drivers\CMSIS\Include;applications;..\..\..\components\drivers\phy;..\..\..\components\libc\compilers\common\extension;..\libraries\STM32H7xx_HAL\STM32H7xx_HAL_Driver\Inc;board\port;..\libraries\HAL_Drivers\drivers\config;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\spi;..\..\..\components\drivers\include;board;..\..\..\components\drivers\include;..\..\..\components\libc\posix\io\epoll;..\..\..\libcpu\arm\common;..\..\..\components\drivers\include;..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\components\finsh;board\port\lcd;..\..\..\components\libc\posix\io\eventfd;..\..\..\components\drivers\include;.;..\..\..\components\dfs\dfs_v1\include;..\..\..\components\libc\posix\ipc;..\..\..\components\drivers\smp_call;..\libraries\HAL_Drivers;..\..\..\include;..\..\..\components\drivers\spi\sfud\inc;board\CubeMX_Config\Inc;..\libraries\STM32H7xx_HAL\STM32H7xx_HAL_Driver\Inc\Legacy;..\..\..\components\dfs\dfs_v1\filesystems\devfs
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x8100000 size 0x100000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/i2c/: dev_i2c_bit_ops.c dev_i2c_core.c dev_i2c_dev.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/pin/: dev_pin.c
    ../../../components/drivers/rtc/: dev_rtc.c
    ../../../components/drivers/serial/: dev_serial_v2.c
    ../../../components/drivers/spi/: dev_qspi_core.c dev_spi.c dev_spi_core.c dev_spi_flash_sfud.c
    ../../../components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
  group Drivers
    ../libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32H7xx/Source/Templates/arm/: startup_stm32h750xx.s
    board/CubeMX_Config/Src/: stm32h7xx_hal_msp.c
    board/: board.c
    board/port/lcd/: drv_lcd_spi.c drv_lcd_spi_ext.c
    ../libraries/HAL_Drivers/drivers/: drv_gpio.c drv_qspi.c drv_spi.c drv_usart_v2.c
    ../libraries/HAL_Drivers/: drv_common.c
  group Filesystem
    ../../../components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    ../../../components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    ../../../components/finsh/: cmd.c msh_parse.c msh_file.c shell.c msh.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    ../../../src/klibc/: kstring.c rt_vsnprintf_tiny.c kstdio.c rt_vsscanf.c kerrno.c
  group libcpu
    ../../../libcpu/arm/common/: div0.c showmem.c
    ../../../libcpu/arm/cortex-m7/: context_rvds.S cpu_cache.c cpuport.c
  group Libraries
    ../libraries/STM32H7xx_HAL/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_gpio.c stm32h7xx_hal_i2c.c stm32h7xx_hal_cec.c stm32h7xx_hal_rng.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_cryp.c stm32h7xx_hal.c stm32h7xx_hal_rtc.c stm32h7xx_hal_dma.c stm32h7xx_hal_rcc.c stm32h7xx_hal_usart.c stm32h7xx_hal_mdma.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_qspi.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_pwr.c stm32h7xx_hal_uart.c stm32h7xx_hal_sram.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_comp.c stm32h7xx_hal_crc.c stm32h7xx_hal_cryp_ex.c
    ../libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
