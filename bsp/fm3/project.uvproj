# Keil uVision project project.uvproj, settings and files
target RT-Thread FM3 (ARM-ADS)
  device: MB9BF500R Fujitsu Microelectronics
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x00000000-0x0003FFFF) CLOCK(4000000) CPUTYPE("Cortex-M3")
  output: rtthread-fm3
  c flags: Optim=1
  c include: .\CMSIS;.;..\..\libcpu\arm\fm3;..\..\include;..\..\components\rtgui\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Startup
    ./: application.c board.c startup.c adc.c cpuusage.c info.c key.c lcd.c led.c
  group Kernel
    ../../src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group FM3
    ../../libcpu/arm/fm3/: context_rvds.S fault_rvds.S start_rvds.S cpuport.c
  group CMSIS
    ./CMSIS/: core_cm3.c system_mb9bf50x.c
  group Rtgui
    ../../components/rtgui/common/: asc12font.c asc16font.c blit.c color.c dc.c dc_buffer.c dc_client.c dc_hw.c filerw.c font.c font_bmp.c font_freetype.c font_hz_bmp.c font_hz_file.c image.c image_bmp.c image_container.c image_hdc.c image_jpg.c image_png.c image_xpm.c region.c rtgui_object.c rtgui_system.c rtgui_theme.c rtgui_xml.c
    ../../components/rtgui/server/: driver.c mouse.c panel.c server.c topwin.c
    ../../components/rtgui/widgets/: about_view.c box.c button.c checkbox.c combobox.c container.c filelist_view.c iconbox.c label.c list_view.c listbox.c listctrl.c menu.c notebook.c progressbar.c radiobox.c scrollbar.c slider.c staticline.c textbox.c title.c toplevel.c view.c widget.c window.c workbench.c
