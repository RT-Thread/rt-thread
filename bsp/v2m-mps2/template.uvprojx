# Keil uVision project template.uvprojx, settings and files
target RT-Thread V2M-MPS2 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: CMSDK_CM7_SP ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.6.0
  cpu: IRAM(0x20000000,0x00400000) IROM(0x00000000,0x00400000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: rtthread-v2m-mps2
  AfterMake: fromelf --bin !L --output rtthread-mdk.bin
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: RT_USING_ARM_LIBC
  c misc: --library_interface=armcc --library_type=standardlib --diag_suppress=66,1296,186
  c include: applications;.;drivers;..\..\include;..\..\libcpu\arm\cortex-m7;..\..\libcpu\arm\common;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\finsh;..\..\components\libc\compilers\armlibc
  memory RVCT4: ROM 0x0 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x400000
  scatter file: .\rtthread-v2m-mps2.sct
  link misc: --keep *.o(.rti_fn.*)   --keep *.o(FSymTab) --keep *.o(VSymTab)
software components: CMSIS:CORE 5.0.2, Board Support:Common 2.0.0, Device:Startup 1.0.0
