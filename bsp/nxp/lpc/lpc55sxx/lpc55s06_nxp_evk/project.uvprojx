# Keil uVision project project.uvprojx, settings and files
target rtthread-lpc55s06 (6160000::V6.16::ARMCLANG)
  device: LPC55S06JBD64 NXP
  pack: NXP.LPC55S06_DFP.14.0.0
  cpu: IRAM(0x10000000,0x03d800) IRAM2(0x20000000,0x010000) IROM(0x03000000,0x020000) IROM2(0x13000000,0x020000) XRAM(0x30000000,0x010000) XRAM2(0x20010000,0x4000) XRAM3(0x30010000,0x4000) XROM(0x00000000,0x03d800) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: rtthread +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=3
  c define: __STDC_LIMIT_MACROS, __CLK_TCK=RT_TICK_PER_SECOND, __RTTHREAD__, RT_USING_ARMLIBC, DEBUG, RT_USING_LIBC
  c misc: --target=arm-arm-none-eabi
  c include: ..\..\..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\libc\compilers\common\include;..\..\..\..\..\components\finsh;..\..\..\..\..\components\libc\posix\ipc;..\Libraries\CMSIS\Core\Include;..\Libraries\drivers;..\..\..\..\..\components\drivers\phy;..\..\..\..\..\components\drivers\include;..\Libraries\LPC55S06\LPC55S06\drivers;..\..\..\..\..\components\libc\posix\io\epoll;..\..\..\..\..\components\libc\posix\io\poll;.;..\..\..\..\..\components\libc\posix\io\eventfd;..\..\..\..\..\components\drivers\smp_call;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\drivers\include;..\Libraries\LPC55S06\components\codec;..\..\..\..\..\libcpu\arm\common;..\..\..\..\..\libcpu\arm\cortex-m33;board;..\Libraries\LPC55S06\LPC55S06;board\MCUX_Config\board;..\..\..\..\..\include;..\..\..\..\..\components\drivers\include;applications;..\..\..\..\..\components\libc\compilers\common\extension;..\Libraries\LPC55S06\middleware\sdmmc\port
  asm misc: -x assembler-with-cpp
  memory RVCT1: ROM 0x0 size 0x3d800
  memory RVCT4: ROM 0x3000000 size 0x20000
  memory RVCT5: ROM 0x13000000 size 0x20000
  memory RVCT6: RAM 0x30000000 size 0x10000
  memory RVCT7: RAM 0x20010000 size 0x4000
  memory RVCT8: RAM 0x30010000 size 0x4000
  memory RVCT9: RAM 0x10000000 size 0x3d800
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: .\board\linker_scripts\LPC55S06_flash.scf
  group Applications
    applications/: main.c
  group Compiler
    ../../../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../../../components/drivers/core/: device.c
    ../../../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../../components/drivers/pin/: dev_pin.c
    ../../../../../components/drivers/serial/: dev_serial.c
  group Drivers
    board/MCUX_Config/board/: clock_config.c pin_mux.c
    board/: board.c
    ../Libraries/drivers/: drv_pin.c drv_uart.c
  group Finsh
    ../../../../../components/finsh/: msh_parse.c cmd.c shell.c msh.c
  group Kernel
    ../../../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    ../../../../../src/klibc/: rt_vsnprintf_tiny.c kerrno.c kstdio.c rt_vsscanf.c kstring.c
  group libcpu
    ../../../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../../../libcpu/arm/cortex-m33/: context_rvds.S cpuport.c syscall_rvds.S trustzone.c
  group Libraries
    ../Libraries/LPC55S06/LPC55S06/drivers/: fsl_mrt.c fsl_crc.c fsl_reset.c fsl_spi_dma.c fsl_i2s_dma.c fsl_dma.c fsl_lpadc.c fsl_common_arm.c fsl_hashcrypt.c fsl_i2c.c fsl_rtc.c fsl_casper.c fsl_ctimer.c fsl_sysctl.c fsl_plu.c fsl_flexcomm.c fsl_common.c fsl_cmp.c fsl_ostimer.c fsl_rng.c fsl_clock.c fsl_usart_dma.c fsl_iap.c fsl_gint.c fsl_spi.c fsl_puf.c fsl_i2c_dma.c fsl_gpio.c fsl_i2s.c fsl_wwdt.c fsl_inputmux.c fsl_power.c fsl_anactrl.c fsl_pint.c fsl_sctimer.c fsl_utick.c fsl_usart.c
    ../Libraries/LPC55S06/LPC55S06/arm/: startup_LPC55S06.s
    ../Libraries/LPC55S06/LPC55S06/: system_LPC55S06.c
