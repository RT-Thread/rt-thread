# Keil uVision project project.uvprojx, settings and files
target rtthread-frdm-mcxa153 (6190000::V6.19::ARMCLANG)
  device: MCXA153VLH NXP
  pack: NXP.MCXA153_DFP.17.0.0
  cpu: IRAM(0x20000000,0x6000) IRAM2(0x04000000,0x2000) IROM(0x03000000,0x2000) IROM2(0x00000000,0x020000) XRAM(0x04002000,0x1000) CPUTYPE("Cortex-M33") CLOCK(12000000) ELITTLE
  output: rtthread
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=3
  c define: __STDC_LIMIT_MACROS, RT_USING_ARMLIBC, RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND, CPU_MCXA153VLH, __RTTHREAD__, DEBUG
  c misc: --target=arm-arm-none-eabi
  c include: ..\libraries\drivers\config;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\libraries\MCXA153\MCXA153\drivers;..\..\..\..\..\components\libc\compilers\common\include;board\MCUX_Config\board;..\libraries\drivers;..\..\..\..\..\components\finsh;..\libraries\MCXA153\MCXA153;..\..\..\..\..\components\libc\posix\io\epoll;..\..\..\..\..\libcpu\arm\common;..\..\..\..\..\components\drivers\include;..\..\..\..\..\include;board;..\..\..\..\..\components\libc\posix\io\eventfd;..\libraries\MCXA153\middleware\sdmmc\inc;..\..\..\..\..\components\libc\posix\io\poll;..\..\..\..\..\libcpu\arm\cortex-m33;..\..\..\..\..\components\drivers\include;.;..\..\..\..\..\components\libc\compilers\common\extension;..\libraries\MCXA153\components\codec;..\libraries\CMSIS\Core\Include;..\libraries\MCXA153\middleware\sdmmc\port;..\..\..\..\..\components\utilities\ulog;applications;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\libc\posix\ipc;..\..\..\..\..\components\drivers\include
  asm misc: -x assembler-with-cpp
  memory RVCT4: ROM 0x3000000 size 0x2000
  memory RVCT5: ROM 0x0 size 0x20000
  memory RVCT6: RAM 0x4002000 size 0x1000
  memory RVCT9: RAM 0x20000000 size 0x6000
  memory RVCT10: RAM 0x4000000 size 0x2000
  scatter file: .\board\linker_scripts\MCXA153_flash.scf
  group Applications
    applications/: main.c
  group Compiler
    ../../../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../../../components/drivers/core/: device.c
    ../../../../../components/drivers/clock_time/: clock_timer.c
    ../../../../../components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../../components/drivers/pin/: pin.c
    ../../../../../components/drivers/serial/: serial.c
  group Drivers
    board/MCUX_Config/board/: clock_config.c pin_mux.c
    board/: board.c
    ../libraries/drivers/: drv_pin.c drv_uart.c
  group Finsh
    ../../../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../../../../src/: clock.c components.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
    ../../../../../src/klibc/: kstdio.c kstring.c
  group libcpu
    ../../../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../../../libcpu/arm/cortex-m33/: context_rvds.S cpuport.c syscall_rvds.S trustzone.c
  group Libraries
    ../libraries/MCXA153/MCXA153/drivers/: fsl_lpuart.c fsl_common_arm.c fsl_lpcmp.c fsl_utick.c fsl_glikey.c fsl_eqdc.c fsl_wwdt.c fsl_i3c_edma.c fsl_pwm.c fsl_gpio.c fsl_lptmr.c fsl_common.c fsl_reset.c fsl_wuu.c fsl_crc.c fsl_edma.c fsl_clock.c fsl_i3c.c fsl_ctimer.c fsl_freqme.c fsl_waketimer.c fsl_vbat.c fsl_spc.c fsl_inputmux.c fsl_lpuart_edma.c fsl_lpadc.c fsl_aoi.c fsl_lpi2c.c fsl_ostimer.c fsl_eim.c fsl_erm.c fsl_lpi2c_edma.c fsl_cmc.c fsl_edma_soc.c
    ../libraries/MCXA153/MCXA153/: system_MCXA153.c
    ../libraries/MCXA153/MCXA153/arm/: startup_MCXA153.s
  group rt_kprintf
    packages/rt_vsnprintf_full-latest/: rt_vsnprintf.c
  group Utilities
    ../../../../../components/utilities/ulog/: ulog.c
    ../../../../../components/utilities/ulog/backend/: console_be.c
