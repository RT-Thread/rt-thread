# Keil uVision project project.uvproj, settings and files
target rtthread (ARM-ADS)
  device: Nuvoton_ARM9_Series Nuvoton
  output: rtthread
  c flags: Optim=3 wLevel=2
  c define: __RTTHREAD__, RT_USING_ARM_LIBC, __CLK_TCK=RT_TICK_PER_SECOND
  c misc: --c99
  c include: applications;.;board;..\..\..\components\libc\compilers\common;..\..\..\components\libc\compilers\common\nogcc;..\..\..\libcpu\arm\common;..\..\..\libcpu\arm\arm926;..\..\..\components\drivers\audio;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\hwcrypto;.;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\spi;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\touch;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\libraries\nuc980\rtt_port;..\..\..\components\dfs\include;..\..\..\components\dfs\filesystems\devfs;..\..\..\components\dfs\filesystems\elmfat;..\..\..\components\finsh;.;..\..\..\include;..\libraries\nuc980\Driver\Include;packages\LVGL-v8.1.0\src;packages\LVGL-v8.1.0\src\core;packages\LVGL-v8.1.0\src\draw;packages\LVGL-v8.1.0\src\extra;packages\LVGL-v8.1.0\src\font;packages\LVGL-v8.1.0\src\gpu;packages\LVGL-v8.1.0\src\hal;packages\LVGL-v8.1.0\src\misc;packages\LVGL-v8.1.0\src\widgets;packages\LVGL-v8.1.0\src\extra\layouts;packages\LVGL-v8.1.0\src\extra\libs;packages\LVGL-v8.1.0\src\extra\others;packages\LVGL-v8.1.0\src\extra\themes;packages\LVGL-v8.1.0\src\extra\widgets;packages\LVGL-v8.1.0\src\extra\layouts\flex;packages\LVGL-v8.1.0\src\extra\layouts\grid;packages\LVGL-v8.1.0\src\extra\libs\bmp;packages\LVGL-v8.1.0\src\extra\libs\freetype;packages\LVGL-v8.1.0\src\extra\libs\fsdrv;packages\LVGL-v8.1.0\src\extra\libs\gif;packages\LVGL-v8.1.0\src\extra\libs\png;packages\LVGL-v8.1.0\src\extra\libs\qrcode;packages\LVGL-v8.1.0\src\extra\libs\rlottie;packages\LVGL-v8.1.0\src\extra\libs\sjpg;packages\LVGL-v8.1.0\src\extra\others\snapshot;packages\LVGL-v8.1.0\src\extra\themes\basic;packages\LVGL-v8.1.0\src\extra\themes\default;packages\LVGL-v8.1.0\src\extra\themes\mono;packages\LVGL-v8.1.0\src\extra\widgets\animimg;packages\LVGL-v8.1.0\src\extra\widgets\calendar;packages\LVGL-v8.1.0\src\extra\widgets\chart;packages\LVGL-v8.1.0\src\extra\widgets\colorwheel;packages\LVGL-v8.1.0\src\extra\widgets\imgbtn;packages\LVGL-v8.1.0\src\extra\widgets\keyboard;packages\LVGL-v8.1.0\src\extra\widgets\led;packages\LVGL-v8.1.0\src\extra\widgets\list;packages\LVGL-v8.1.0\src\extra\widgets\meter;packages\LVGL-v8.1.0\src\extra\widgets\msgbox;packages\LVGL-v8.1.0\src\extra\widgets\span;packages\LVGL-v8.1.0\src\extra\widgets\spinbox;packages\LVGL-v8.1.0\src\extra\widgets\spinner;packages\LVGL-v8.1.0\src\extra\widgets\tabview;packages\LVGL-v8.1.0\src\extra\widgets\tileview;packages\LVGL-v8.1.0\src\extra\widgets\win;packages\LVGL-v8.1.0\src\gpu\sdl;applications\lvgl;packages\LVGL-v8.1.0\rt-thread;..\..\..\components\net\lwip-2.1.2\src;..\..\..\components\net\lwip-2.1.2\src\include;..\..\..\components\net\lwip-2.1.2\src\arch\include;..\..\..\components\net\lwip-2.1.2\src\include\netif;packages\netutils-v1.3.1\ntp;packages\netutils-v1.3.1\tftp;.;..\libraries\nu_packages\Demo;..\libraries\nu_packages\ILI9341;..\libraries\nu_packages\AudioCodec;..\libraries\nu_packages\SPINAND;..\libraries\nuc980\UsbHostLib\inc;..\libraries\nu_packages\NuUtils\inc;packages\optparse-latest;..\..\..\components\libc\posix\io;..\..\..\components\libc\posix\io\poll;..\..\..\components\libc\posix\ipc;packages\ramdisk-latest\inc;..\..\..\components\drivers\usb\usbdevice;..\..\..\components\drivers\usb\usbhost;..\..\..\components\drivers\usb\usbhost\class;..\..\..\components\drivers\usb\usbhost\core;..\..\..\components\drivers\usb\usbhost\include;..\..\..\components\drivers\include;..\..\..\components\net\netdev\include;..\..\..\components\net\sal_socket\include;..\..\..\components\net\sal_socket\include\socket;..\..\..\components\net\sal_socket\impl;..\..\..\components\net\sal_socket\include\dfs_net;..\..\..\components\net\sal_socket\include\socket\sys_socket;packages\uffs-latest;packages\uffs-latest\src\inc;..\..\..\components\utilities\utest;..\..\..\examples\utest\testcases\kernel;packages\wavplayer-latest;packages\wavplayer-latest\inc
  scatter file: .\linking_scripts\nuc980.sct
  group Applications
    applications/: mnt.c main.c
  group board
    board/: board_dev.c nu_pin_init.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c libc_syms.c
    ../../../components/libc/compilers/common/: stdlib.c time.c
  group CPU
    ../../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../../libcpu/arm/arm926/: stack.c context_rvds.S machine.c start_rvds.S cpuport.c mmu.c trap.c
  group DeviceDrivers
    ../../../components/drivers/audio/: audio.c audio_pipe.c
    ../../../components/drivers/can/: can.c
    ../../../components/drivers/cputime/: cputime.c
    ../../../components/drivers/hwcrypto/: hw_symmetric.c hwcrypto.c hw_rng.c hw_hash.c
    ../../../components/drivers/hwtimer/: hwtimer.c
    ../../../components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    ../../../components/drivers/misc/: adc.c rt_drv_pwm.c pin.c
    ../../../components/drivers/mtd/: mtd_nand.c
    ../../../components/drivers/rtc/: rtc.c alarm.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/spi/: spi_core.c spi_dev.c qspi_core.c
    ../../../components/drivers/src/: dataqueue.c ringblk_buf.c workqueue.c ringbuffer.c completion.c pipe.c waitqueue.c
    ../../../components/drivers/touch/: touch.c
    ../../../components/drivers/watchdog/: watchdog.c
  group Drivers
    ../libraries/nuc980/rtt_port/: drv_i2s.c drv_spi.c drv_gpio.c drv_sdh.c drv_scuart.c drv_usbhost.c drv_wdt.c drv_ebi.c drv_etimer.c drv_sys.c drv_adc.c drv_rtc.c drv_usbd.c drv_softi2c.c drv_common.c drv_etimer_capture.c drv_i2c.c drv_pdma.c drv_systick.c drv_uart.c drv_can.c drv_qspi.c drv_crypto.c drv_pwm.c drv_emac.c
  group Filesystem
    ../../../components/dfs/src/: dfs_posix.c dfs_fs.c dfs.c dfs_file.c
    ../../../components/dfs/filesystems/devfs/: devfs.c
    ../../../components/dfs/filesystems/elmfat/: ff.c ffunicode.c dfs_elm.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c msh_file.c cmd.c
  group Kernel
    ../../../src/: kservice.c components.c idle.c ipc.c memheap.c device.c irq.c thread.c mem.c timer.c signal.c clock.c mempool.c scheduler.c object.c
  group Libraries
    ../libraries/nuc980/Driver/Source/: nu_can.c nu_wwdt.c nu_wdt.c nu_scuart.c nu_cap.c nu_sys.c nu_rtc.c nu_crypto.c nu_i2s.c nu_etimer.c nu_pdma.c nu_uart.c nu_ebi.c nu_usbd.c nu_gpio.c nu_emac.c nu_sdh.c nu_i2c.c nu_qspi.c nu_spi.c
  group LVGL
    packages/LVGL-v8.1.0/src/widgets/: lv_switch.c lv_img.c lv_roller.c lv_table.c lv_textarea.c lv_checkbox.c lv_label.c lv_arc.c lv_dropdown.c lv_bar.c lv_slider.c lv_objx_templ.c lv_line.c lv_btnmatrix.c lv_canvas.c lv_btn.c
    packages/LVGL-v8.1.0/src/core/: lv_disp.c lv_event.c lv_refr.c lv_theme.c lv_group.c lv_indev.c lv_obj_draw.c lv_obj_style.c lv_obj_style_gen.c lv_obj_pos.c lv_obj_tree.c lv_obj_class.c lv_indev_scroll.c lv_obj_scroll.c lv_obj.c
    packages/LVGL-v8.1.0/src/font/: lv_font_montserrat_8.c lv_font_montserrat_26.c lv_font_montserrat_46.c lv_font_montserrat_28.c lv_font_montserrat_12_subpx.c lv_font_montserrat_38.c lv_font_loader.c lv_font_montserrat_16.c lv_font_montserrat_44.c lv_font_montserrat_32.c lv_font_montserrat_10.c lv_font_montserrat_22.c lv_font_montserrat_34.c lv_font_montserrat_40.c lv_font_montserrat_14.c lv_font.c lv_font_unscii_8.c lv_font_montserrat_20.c lv_font_montserrat_48.c lv_font_dejavu_16_persian_hebrew.c lv_font_montserrat_28_compressed.c lv_font_montserrat_42.c lv_font_montserrat_12.c lv_font_montserrat_30.c lv_font_fmt_txt.c lv_font_montserrat_36.c lv_font_unscii_16.c lv_font_montserrat_18.c lv_font_simsun_16_cjk.c lv_font_montserrat_24.c
    packages/LVGL-v8.1.0/src/misc/: lv_math.c lv_mem.c lv_style_gen.c lv_bidi.c lv_timer.c lv_utils.c lv_anim.c lv_async.c lv_color.c lv_tlsf.c lv_txt.c lv_gc.c lv_fs.c lv_area.c lv_log.c lv_printf.c lv_style.c lv_ll.c lv_templ.c lv_txt_ap.c lv_anim_timeline.c
    packages/LVGL-v8.1.0/src/extra/widgets/calendar/: lv_calendar_header_dropdown.c lv_calendar.c lv_calendar_header_arrow.c
    packages/LVGL-v8.1.0/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    packages/LVGL-v8.1.0/src/extra/: lv_extra.c
    packages/LVGL-v8.1.0/src/gpu/sdl/: lv_gpu_sdl_lru.c lv_gpu_sdl_utils.c lv_gpu_sdl_draw_rect.c lv_gpu_sdl_draw_label.c lv_gpu_sdl_draw_img.c lv_gpu_sdl_draw_arc.c lv_gpu_sdl_stack_blur.c lv_gpu_sdl_texture_cache.c lv_gpu_sdl_draw_line.c lv_gpu_sdl_draw_blend.c lv_gpu_sdl_mask.c
    packages/LVGL-v8.1.0/src/extra/layouts/grid/: lv_grid.c
    packages/LVGL-v8.1.0/src/gpu/: lv_gpu_sdl.c lv_gpu_nxp_pxp.c lv_gpu_nxp_vglite.c lv_gpu_stm32_dma2d.c lv_gpu_nxp_pxp_osa.c
    packages/LVGL-v8.1.0/src/extra/libs/gif/: lv_gif.c gifdec.c
    packages/LVGL-v8.1.0/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    packages/LVGL-v8.1.0/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    packages/LVGL-v8.1.0/src/extra/widgets/span/: lv_span.c
    packages/LVGL-v8.1.0/src/extra/libs/fsdrv/: lv_fs_stdio.c lv_fs_win32.c lv_fs_posix.c lv_fs_fatfs.c
    packages/LVGL-v8.1.0/src/draw/: lv_draw_triangle.c lv_img_decoder.c lv_draw_arc.c lv_img_cache.c lv_draw_rect.c lv_draw_label.c lv_draw_blend.c lv_draw_img.c lv_draw_line.c lv_img_buf.c lv_draw_mask.c
    packages/LVGL-v8.1.0/src/extra/themes/default/: lv_theme_default.c
    packages/LVGL-v8.1.0/src/extra/libs/freetype/: lv_freetype.c
    packages/LVGL-v8.1.0/src/extra/themes/basic/: lv_theme_basic.c
    packages/LVGL-v8.1.0/src/extra/layouts/flex/: lv_flex.c
    packages/LVGL-v8.1.0/src/extra/widgets/animimg/: lv_animimg.c
    packages/LVGL-v8.1.0/src/extra/widgets/chart/: lv_chart.c
    packages/LVGL-v8.1.0/src/extra/widgets/tabview/: lv_tabview.c
    packages/LVGL-v8.1.0/src/extra/widgets/keyboard/: lv_keyboard.c
    packages/LVGL-v8.1.0/src/extra/libs/bmp/: lv_bmp.c
    packages/LVGL-v8.1.0/src/extra/widgets/spinner/: lv_spinner.c
    packages/LVGL-v8.1.0/src/extra/widgets/spinbox/: lv_spinbox.c
    packages/LVGL-v8.1.0/src/extra/libs/png/: lodepng.c lv_png.c
    packages/LVGL-v8.1.0/src/extra/others/snapshot/: lv_snapshot.c
    packages/LVGL-v8.1.0/src/extra/widgets/list/: lv_list.c
    packages/LVGL-v8.1.0/src/extra/widgets/msgbox/: lv_msgbox.c
    packages/LVGL-v8.1.0/src/extra/widgets/tileview/: lv_tileview.c
    packages/LVGL-v8.1.0/src/extra/themes/mono/: lv_theme_mono.c
    packages/LVGL-v8.1.0/src/extra/widgets/meter/: lv_meter.c
    packages/LVGL-v8.1.0/src/extra/widgets/win/: lv_win.c
    packages/LVGL-v8.1.0/src/extra/libs/rlottie/: lv_rlottie.c
    packages/LVGL-v8.1.0/src/extra/widgets/colorwheel/: lv_colorwheel.c
    packages/LVGL-v8.1.0/src/extra/widgets/led/: lv_led.c
    packages/LVGL-v8.1.0/src/extra/widgets/imgbtn/: lv_imgbtn.c
  group LVGL-demo
    packages/lv_music_demo-v0.1.1/assets/: img_lv_demo_rtt_music_btn_pause.c img_lv_demo_rtt_music_wave_top.c img_lv_demo_rtt_music_btn_next.c img_lv_demo_rtt_music_icon_1.c img_lv_demo_rtt_music_btn_play.c img_lv_demo_rtt_music_btn_loop.c img_lv_demo_rtt_music_cover_2.c img_lv_demo_rtt_music_wave_bottom.c img_lv_demo_rtt_music_btn_list_pause.c img_lv_demo_rtt_music_icon_4.c img_lv_demo_rtt_music_slider_knob.c img_lv_demo_rtt_music_cover_3.c img_lv_demo_rtt_music_icon_3.c img_lv_demo_rtt_music_corner_right.c img_lv_demo_rtt_music_btn_rnd.c img_lv_demo_rtt_music_icon_2.c img_lv_demo_rtt_music_corner_left.c img_lv_demo_rtt_music_btn_prev.c img_lv_demo_rtt_music_logo.c img_lv_demo_rtt_music_btn_list_play.c img_lv_demo_rtt_music_list_border.c img_lv_demo_rtt_music_cover_1.c
    packages/lv_music_demo-v0.1.1/: lv_demo_rtt_music_main.c lv_demo_rtt_music_list.c lv_demo_rtt_music.c
  group LVGL-port
    applications/lvgl/: lv_demo.c lv_port_disp.c lv_port_indev.c
    packages/LVGL-v8.1.0/rt-thread/: lv_rt_thread_port.c
  group lwIP
    ../../../components/net/lwip-2.1.2/src/api/: netdb.c sockets.c netifapi.c tcpip.c netbuf.c api_lib.c err.c api_msg.c if_api.c
    ../../../components/net/lwip-2.1.2/src/core/: ip.c netif.c sys.c altcp_alloc.c init.c memp.c raw.c tcp_out.c inet_chksum.c stats.c altcp.c tcp_in.c dns.c timeouts.c udp.c altcp_tcp.c pbuf.c def.c tcp.c
    ../../../components/net/lwip-2.1.2/src/core/ipv4/: autoip.c ip4_addr.c dhcp.c etharp.c ip4.c ip4_frag.c icmp.c igmp.c
    ../../../components/net/lwip-2.1.2/src/netif/: ethernet.c ethernetif.c lowpan6.c
    ../../../components/net/lwip-2.1.2/src/arch/: sys_arch.c
    ../../../components/net/lwip-2.1.2/src/apps/ping/: ping.c
  group NetUtils
    packages/netutils-v1.3.1/iperf/: iperf.c
    packages/netutils-v1.3.1/ntp/: ntp.c
    packages/netutils-v1.3.1/tftp/: tftp_port.c tftp_xfer.c tftp_client.c tftp_server.c
  group nu_pkgs_demo
    ../libraries/nu_packages/Demo/: usbd_cdc_vcom_echo.c slcd_show_tick.c usbd_hid_dance_mouse.c
  group nu_pkgs_ili9341
    ../libraries/nu_packages/ILI9341/: ili9341_spi.c lcd_ili9341.c
  group nu_pkgs_nau8822
    ../libraries/nu_packages/AudioCodec/: audio_test.c acodec_nau8822.c
  group nu_pkgs_spinand
    ../libraries/nu_packages/SPINAND/: spinand.c drv_spinand.c
  group nuc980_usbhostlib
    ../libraries/nuc980/UsbHostLib/src/: ehci_iso.c ehci.c mem_alloc.c support.c ohci.c usb_core.c
  group optparse
    packages/optparse-latest/: optparse.c
  group POSIX
    ../../../components/libc/posix/io/: select.c
    ../../../components/libc/posix/io/poll/: poll.c
  group ramdisk
    packages/ramdisk-latest/src/: drv_ramdisk.c
  group rt_usbd
    ../../../components/drivers/usb/usbdevice/class/: cdc_vcom.c mstorage.c
    ../../../components/drivers/usb/usbdevice/core/: usbdevice_core.c usbdevice.c
  group rt_usbh
    ../../../components/drivers/usb/usbhost/class/: udisk.c mass.c
    ../../../components/drivers/usb/usbhost/core/: hub.c usbhost.c usbhost_core.c driver.c
  group SAL
    ../../../components/net/netdev/src/: netdev.c netdev_ipaddr.c
    ../../../components/net/sal_socket/socket/: net_netdb.c net_sockets.c
    ../../../components/net/sal_socket/src/: sal_socket.c
    ../../../components/net/sal_socket/dfs_net/: dfs_net.c
    ../../../components/net/sal_socket/impl/: af_inet_lwip.c
  group uffs
    packages/uffs-latest/src/uffs/: uffs_mem.c uffs_mtb.c uffs_crc.c uffs_tree.c uffs_flash.c uffs_version.c uffs_debug.c uffs_blockinfo.c uffs_public.c uffs_find.c uffs_buf.c uffs_pool.c uffs_device.c uffs_fd.c uffs_utils.c uffs_ecc.c uffs_badblock.c uffs_init.c uffs_fs.c
    packages/uffs-latest/: uffs_nandif.c dfs_uffs.c uffs_rtthread.c
  group UTest
    ../../../components/utilities/utest/: utest.c
  group wavplayer
    packages/wavplayer-latest/src/: wavplayer.c wavplayer_cmd.c wavrecorder.c wavhdr.c wavrecorder_cmd.c
