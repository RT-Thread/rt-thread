# Keil uVision project template.uvprojx, settings and files
target rtthread-frdm-mcxc162 (6230000::V6.23::ARMCLANG)
  device: MCXC162VFT NXP
  pack: NXP.MCXC162_DFP.26.06.00
  cpu: IRAM(0x20000000,0x00003000) IROM(0x00000000,0x00010000) CPUTYPE("Cortex-M23") CLOCK(72000000) ELITTLE
  output: rtthread
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=3
  c define: RT_USING_ARM_LIBC
  c misc: --target=arm-arm-none-eabi -mcpu=cortex-m23 -mfloat-abi=soft
  asm misc: -x assembler-with-cpp
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x3000
  scatter file: .\packages\nxp-mcx-series-latest\MCXC162\arm\MCXC162_flash.scf
  link misc: --keep *.o(.rti_fn.*)   --keep *.o(FSymTab) --keep *.o(VSymTab)
