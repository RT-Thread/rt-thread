# Keil uVision project template.uvprojx, settings and files
target rt-thread_gd32f30x (ARM-ADS)
  device: GD32F350R8 GigaDevice
  pack: GigaDevice.GD32F3x0_DFP.2.0.0
  cpu: IRAM(0x20000000,0x04000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rtthread-gd32f3x0 +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=4 uC99=1 v6Lang=1 v6LangP=1
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
software components: CMSIS:CORE 5.4.0
