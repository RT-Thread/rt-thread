# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32WLE5JCIx STMicroelectronics
  pack: Keil.STM32WLxx_DFP.1.0.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_HAL_DRIVER, STM32WLxx, __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND
  c include: applications;.;..\..\..\libcpu\arm\common;..\..\..\libcpu\arm\cortex-m4;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;board;board\CubeMX_Config\Inc;board\ports;..\libraries\HAL_Drivers;..\libraries\HAL_Drivers\config;..\..\..\components\finsh;.;..\..\..\include;..\..\..\components\libc\compilers\common;..\..\..\components\libc\compilers\common\nogcc;..\libraries\STM32WLxx_HAL\STM32WLxx_HAL_Driver\Inc;..\libraries\STM32WLxx_HAL\CMSIS\Device\ST\stm32lwxx\Include;..\libraries\STM32WLxx_HAL\CMSIS\Include;..\..\..\examples\utest\testcases\kernel
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group CPU
    ../../../libcpu/arm/common/: showmem.c backtrace.c div0.c
    ../../../libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
  group DeviceDrivers
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/src/: dataqueue.c pipe.c completion.c workqueue.c waitqueue.c ringblk_buf.c ringbuffer.c
  group Drivers
    board/CubeMX_Config/Src/: stm32wlxx_hal_msp.c
    ../libraries/STM32WLxx_HAL/CMSIS/Device/ST/STM32WLxx/Source/Templates/arm/: startup_stm32wle5xx.s
    board/: board.c
    ../libraries/HAL_Drivers/: drv_gpio.c drv_usart.c drv_common.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c cmd.c
  group Kernel
    ../../../src/: components.c ipc.c timer.c irq.c idle.c mem.c clock.c kservice.c mempool.c scheduler.c object.c device.c thread.c
  group STM32_HAL
    ../libraries/STM32WLxx_HAL/STM32WLxx_HAL_Driver/Src/: stm32wlxx_hal_pwr.c stm32wlxx_hal_dma_ex.c stm32wlxx_hal_gpio.c stm32wlxx_hal_rcc_ex.c stm32wlxx_hal_usart.c stm32wlxx_hal_pwr_ex.c stm32wlxx_hal_cryp.c stm32wlxx_hal_usart_ex.c stm32wlxx_hal_exti.c stm32wlxx_hal_cortex.c stm32wlxx_hal_uart_ex.c stm32wlxx_hal.c stm32wlxx_hal_rcc.c stm32wlxx_hal_dma.c stm32wlxx_hal_uart.c stm32wlxx_hal_comp.c stm32wlxx_hal_rng.c stm32wlxx_hal_crc.c stm32wlxx_hal_crc_ex.c stm32wlxx_hal_cryp_ex.c
    ../libraries/STM32WLxx_HAL/CMSIS/Device/ST/STM32WLxx/Source/Templates/: system_stm32wlxx.c
