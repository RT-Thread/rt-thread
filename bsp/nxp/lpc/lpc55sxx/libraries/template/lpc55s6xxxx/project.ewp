# IAR project project.ewp, settings and files
configuration rtthread-lpc55s6x (ARM, debug)
  General.OGChipSelectEditMenu: LPC55S66_core0 NXP LPC55S66_core0
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: ARM_MATH_CM33; RT_USING_ARM_LIBC; CPU_LPC55S69JBD100_cm33_core0; RT_USING_DLIBC; _DLIB_FILE_DESCRIPTOR
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..\..\..\components\dfs\filesystems\devfs; ..\..\..\components\finsh; ..\..\..\components\drivers\include; ..\..\..\components\libc\compilers\dlib; ..\..\..\components\libc\compilers\common; ..\..\..\components\dfs\include; ..\Libraries\LPC55S6X\LPC55S6X; ..\Libraries\drivers\config; .; board; ..\..\..\components\drivers\spi; board\MCUX_Config; board\ports; ..\Libraries\drivers; ..\Libraries\LPC55S6X\LPC55S6X\drivers; applications; ..\..\..\components\dfs\filesystems\elmfat; ..\Libraries\LPC55S6X\CMSIS\Include; ..\..\..\include; ..\..\..\libcpu\arm\common; ..\..\..\libcpu\arm\cortex-m4; ..\Libraries\LPC55S6X\middleware\sdmmc\inc; ..\Libraries\LPC55S6X\middleware\sdmmc\port; ..\Libraries\LPC55S6X\components\codec
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: project.srec
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: board\linker_scripts\LPC55S69_cm33_core0_flash_iar.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Kernel
    ../../../src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group Applications
    applications/: application.c mnt.c startup.c
  group Drivers
    board/: board.c clock_config.c pin_mux.c
    ../Libraries/drivers/: drv_pin.c drv_led.c drv_uart.c drv_rtc.c drv_spi.c drv_sd.c drv_i2c.c drv_mma8562.c drv_timer.c drv_wdt.c drv_pwm.c
  group cpu
    ../../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m4/: cpuport.c context_iar.S
  group Filesystem
    ../../../components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c poll.c select.c
    ../../../components/dfs/filesystems/devfs/: devfs.c
    ../../../components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
  group DeviceDrivers
    ../../../components/drivers/clock_time/: clock_timer.c
    ../../../components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    ../../../components/drivers/misc/: pin.c adc.c rt_drv_pwm.c
    ../../../components/drivers/rtc/: rtc.c
    ../../../components/drivers/sdio/: block_dev.c mmcsd_core.c sd.c sdio.c mmc.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/spi/: spi_core.c spi_dev.c
    ../../../components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/watchdog/: watchdog.c
  group finsh
    ../../../components/finsh/: shell.c symbol.c cmd.c msh.c msh_cmd.c msh_file.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_var.c finsh_vm.c finsh_token.c
  group libc
    ../../../components/libc/compilers/common/: gmtime_r.c
  group dlib
    ../../../components/libc/compilers/dlib/: environ.c libc.c rmtx.c stdio.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c time.c
  group Libraries
    ../Libraries/LPC55S6X/LPC55S6X/: system_LPC55S69_cm33_core0.c
    ../Libraries/LPC55S6X/LPC55S6X/iar/: startup_LPC55S69_cm33_core0.s iar_lib_power_cm33_core0.a
    ../Libraries/LPC55S6X/LPC55S6X/drivers/: fsl_anactrl.c fsl_casper.c fsl_clock.c fsl_cmp.c fsl_common.c fsl_crc.c fsl_ctimer.c fsl_flexcomm.c fsl_dma.c fsl_gint.c fsl_gpio.c fsl_hashcrypt.c fsl_i2c.c fsl_i2c_dma.c fsl_i2s.c fsl_i2s_dma.c fsl_iap.c fsl_inputmux.c fsl_lpadc.c fsl_mrt.c fsl_ostimer.c fsl_pint.c fsl_plu.c fsl_power.c fsl_powerquad_basic.c fsl_prince.c fsl_puf.c fsl_reset.c fsl_rng.c fsl_rtc.c fsl_sctimer.c fsl_sdif.c fsl_spi.c fsl_spi_dma.c fsl_sysctl.c fsl_usart.c fsl_usart_dma.c fsl_utick.c fsl_wwdt.c
    ../Libraries/LPC55S6X/middleware/sdmmc/src/: fsl_sd.c fsl_sdmmc_common.c
    ../Libraries/LPC55S6X/middleware/sdmmc/port/sdif/rt_thread/: fsl_sdmmc_event.c fsl_sdmmc_host.c
