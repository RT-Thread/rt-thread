# IAR project project.ewp, settings and files
configuration rt-thread (ARM, debug)
  General.OGChipSelectEditMenu: MM32F3277G9P MindMotion MM32F3277G9P
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: __RTTHREAD__; CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; __RT_IPC_SOURCE__; __RT_KERNEL_SOURCE__
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: applications; packages\mm32f3270x-cmsis-latest\CMSIS\Include; packages\mm32f3270x-cmsis-latest\CMSIS\Device\MM32\MM32F3277\Include; ..\..\..\libcpu\arm\common; ..\..\..\libcpu\arm\cortex-m3; ..\..\..\components\drivers\include; ..\..\..\components\drivers\phy; ..\..\..\components\drivers\smp_call; board; ..\libraries\HAL_Drivers\drivers; ..\libraries\HAL_Drivers; ..\libraries\HAL_Drivers\drivers\config; ..\..\..\components\finsh; .; ..\..\..\include; ..\..\..\components\libc\compilers\common\include; ..\..\..\components\libc\compilers\common\extension; ..\..\..\components\libc\compilers\common\extension\fcntl\octal; ..\..\..\components\libc\posix\io\epoll; ..\..\..\components\libc\posix\io\eventfd; ..\..\..\components\libc\posix\io\poll; ..\..\..\components\libc\posix\ipc; packages\mm32f3270x-hal-driver-latest\Inc; ..\..\..\components\net\utest
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../../rtthread.bin
  ILINK.IlinkOutputFile: rtthread.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: main.c
  group CMSIS
    packages/mm32f3270x-cmsis-latest/CMSIS/Device/MM32/MM32F3277/Source/Templates/: system_mm32f3277g.c
    packages/mm32f3270x-cmsis-latest/CMSIS/Device/MM32/MM32F3277/Source/Templates/iar/: startup_mm32f3270.s
  group CPU
    ../../../libcpu/arm/common/: div0.c showmem.c
    ../../../libcpu/arm/cortex-m3/: context_iar.S cpuport.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/pin/: dev_pin.c
    ../../../components/drivers/serial/: dev_serial.c
  group Drivers
    ../libraries/HAL_Drivers/drivers/: drv_gpio.c drv_uart.c
    board/: board.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group Libc
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
    ../../../src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
  group Libraries
    packages/mm32f3270x-hal-driver-latest/Src/: hal_adc.c hal_comp.c hal_dac.c hal_dma.c hal_exti.c hal_fsmc.c hal_gpio.c hal_i2c.c hal_iwdg.c hal_rcc.c hal_rtc.c hal_sdio.c hal_spi.c hal_syscfg.c hal_tim_16b.c hal_tim_32b.c hal_tim_adv.c hal_tim_basic.c hal_uart.c hal_usb.c hal_wwdg.c
