# Keil uVision project project.uvprojx, settings and files
target rt-thread_gd32e230 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32E230K8 GigaDevice
  pack: GigaDevice.GD32E230_DFP.1.0.0
  cpu: IRAM(0x20000000,0x0002000) IROM(0x08000000,0x0010000) CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: rtthread-gd32e230
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: GD32E230, __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND
  c include: applications;..\..\libcpu\arm\common;..\..\libcpu\arm\cortex-m23;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\drivers\spi;..\..\components\drivers\include;..\..\components\drivers\spi\sfud\inc;..\..\components\drivers\include;drivers;..\..\components\finsh;.;..\..\include;..\..\components\libc\compilers\common;..\..\components\libc\compilers\common\nogcc;Libraries\CMSIS\GD\GD32E230\Include;Libraries\CMSIS;Libraries\GD32E230_standard_peripheral\Include;..\..\examples\utest\testcases\kernel
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Applications
    applications/: main.c
  group CPU
    ../../libcpu/arm/common/: showmem.c div0.c backtrace.c
    ../../libcpu/arm/cortex-m23/: cpuport.c context_rvds.S
  group DeviceDrivers
    ../../components/drivers/i2c/: i2c_core.c i2c_dev.c
    ../../components/drivers/misc/: pin.c
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/spi/sfud/src/: sfud.c
    ../../components/drivers/spi/: spi_flash_sfud.c spi_core.c spi_dev.c
    ../../components/drivers/src/: ringblk_buf.c ringbuffer.c dataqueue.c completion.c waitqueue.c workqueue.c pipe.c
  group Drivers
    drivers/: drv_i2c.c drv_gpio.c drv_usart.c board.c drv_spi.c
  group Finsh
    ../../components/finsh/: shell.c msh.c cmd.c
  group Kernel
    ../../src/: device.c mempool.c thread.c ipc.c clock.c idle.c timer.c irq.c object.c kservice.c components.c mem.c scheduler.c
  group libc
    ../../components/libc/compilers/common/: time.c
  group Libraries
    Libraries/GD32E230_standard_peripheral/Source/: gd32e230_fmc.c gd32e230_gpio.c gd32e230_pmu.c gd32e230_exti.c gd32e230_adc.c gd32e230_crc.c gd32e230_misc.c gd32e230_usart.c gd32e230_syscfg.c gd32e230_spi.c gd32e230_timer.c gd32e230_fwdgt.c gd32e230_rtc.c gd32e230_dbg.c gd32e230_cmp.c gd32e230_dma.c gd32e230_wwdgt.c gd32e230_rcu.c gd32e230_i2c.c
    Libraries/CMSIS/GD/GD32E230/Source/ARM/: startup_gd32e230.s
    Libraries/CMSIS/GD/GD32E230/Source/: system_gd32e230.c
software components: CMSIS:CORE 5.2.0
