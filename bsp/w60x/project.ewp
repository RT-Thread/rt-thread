# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: __inline=inline; __inline__=inline; CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; _DLIB_FILE_DESCRIPTOR; _DLIB_THREAD_SUPPORT; __RTTHREAD__; WM_W600; __inline=inline; __inline__=inline
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: packages\netutils-latest\ntp; packages\wm_libraries-latest\Platform\Boot\gcc; oneshot; ..\..\include; ..\..\libcpu\arm\common; ..\..\components\drivers\include; packages\wm_libraries-latest\Include; ..\..\components\dfs\filesystems\devfs; packages\wm_libraries-latest\Platform\Common\crypto\symmetric; ..\..\components\libc\posix\ipc; ..\..\components\net\lwip-dhcpd; drivers; ..\..\components\net\lwip\lwip-2.0.3\src\include\netif; packages\wm_libraries-latest\Platform\Common\crypto\digest; .; packages\wm_libraries-latest\Include\OS; ..\..\components\net\lwip\lwip-2.0.3\src\include; ..\..\components\utilities\ulog; ..\..\libcpu\arm\cortex-m3; packages\wm_libraries-latest\Include\Platform; ..\..\components\net\sal\include\dfs_net; ..\..\components\drivers\hwcrypto; ..\..\components\dfs\include; packages\wm_libraries-latest\Platform\Inc; packages\wm_libraries-latest\Include\WiFi; packages\wm_libraries-latest\Platform\Common\Params; ..\..\components\libc\compilers\common\include; packages\wm_libraries-latest\Platform\Common\crypto; packages\wm_libraries-latest\Platform\Drivers\spi; ..\..\components\drivers\spi; packages\wm_libraries-latest\Platform\Common\crypto\math; applications; ..\..\components\libc\compilers\common\extension\fcntl\octal; ..\..\components\net\lwip\lwip-2.0.3\src\include\ipv4; ..\..\components\net\lwip\port; ..\..\components\finsh; ..\..\components\net\sal\include\socket\sys_socket; ..\..\components\libc\compilers\common\extension; ..\..\components\net\sal\include; ..\..\components\net\sal\impl; ..\..\components\net\netdev\include; packages\wm_libraries-latest\Include\Driver; ..\..\components\libc\posix\io\poll; ..\..\components\libc\posix\io\stdio; ..\..\components\drivers\wlan; ..\..\components\net\sal\include\socket; packages\wm_libraries-latest
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../rtthread.bin
  postbuild: cmd /c "makeimg.bat"
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: .\drivers\linker_scripts\link.icf
  ILINK.IlinkAdditionalLibs: packages\wm_libraries-latest\Lib\Wlan\libwlan_iar.a; packages\wm_libraries-latest\Lib\oneshot\libwmoneshot_iar.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: main.c
  group Compiler
    ../../components/libc/compilers/common/: cctype.c cstdio.c cstdlib.c cstring.c ctime.c cwchar.c
    ../../components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
  group CPU
    ../../libcpu/arm/common/: div0.c showmem.c
    ../../libcpu/arm/cortex-m3/: context_iar.S cpuport.c
  group DeviceDrivers
    ../../components/drivers/hwcrypto/: hw_bignum.c hw_crc.c hw_hash.c hw_rng.c hw_symmetric.c hwcrypto.c
    ../../components/drivers/hwtimer/: hwtimer.c
    ../../components/drivers/i2c/: i2c-bit-ops.c i2c_core.c i2c_dev.c
    ../../components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../components/drivers/misc/: pin.c rt_drv_pwm.c
    ../../components/drivers/rtc/: rtc.c soft_rtc.c
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/spi/: spi_core.c spi_dev.c
    ../../components/drivers/watchdog/: watchdog.c
    ../../components/drivers/wlan/: wlan_cfg.c wlan_cmd.c wlan_dev.c wlan_lwip.c wlan_mgnt.c wlan_prot.c wlan_workqueue.c
  group Drivers
    drivers/: pin_map.c drv_uart.c drv_pin.c drv_flash.c drv_wifi.c board.c
  group Filesystem
    ../../components/dfs/filesystems/devfs/: devfs.c
    ../../components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    ../../components/finsh/: shell.c msh.c msh_parse.c cmd.c msh_file.c
  group Kernel
    ../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_up.c thread.c timer.c
  group Libraries
    packages/wm_libraries-latest/Platform/Drivers/spi/: wm_hostspi.c
    packages/wm_libraries-latest/Platform/Common/crypto/pubkey/: pkcs.c dh.c pubkey.c wm_crypto_rsa.c ecc.c
    packages/wm_libraries-latest/Platform/Common/crypto/digest/: wm_crypto_sha512.c sha224.c wm_crypto_md4.c wm_crypto_hmac.c sha384.c wm_crypto_md2.c
    packages/wm_libraries-latest/Platform/Drivers/gpio/: wm_gpio_afsel.c wm_gpio.c
    packages/wm_libraries-latest/Platform/Common/crypto/keyformat/: wm_crypto_base64.c wm_crypto_x509.c asn1.c
    packages/wm_libraries-latest/Platform/Drivers/timer/: wm_timer.c
    packages/wm_libraries-latest/Platform/Common/crypto/symmetric/: idea.c des3.c rc2.c aesGCM.c seed.c
    packages/wm_libraries-latest/Platform/Drivers/cpu/: wm_cpu.c
    packages/wm_libraries-latest/Platform/Drivers/rtc/: wm_rtc.c
    packages/wm_libraries-latest/Platform/Drivers/i2c/: wm_i2c.c
    packages/wm_libraries-latest/Platform/Boot/iar/: misc.c
    packages/wm_libraries-latest/Platform/Drivers/pwm/: wm_pwm.c
    packages/wm_libraries-latest/Platform/Common/crypto/prng/: prng.c yarrow.c
    packages/wm_libraries-latest/Platform/Drivers/efuse/: wm_efuse.c
    packages/wm_libraries-latest/Platform/Common/fwup/: wm_fwup.c
    packages/wm_libraries-latest/Platform/Drivers/dma/: wm_dma.c
    packages/wm_libraries-latest/Platform/Drivers/internalflash/: wm_internal_fls.c
    packages/wm_libraries-latest/Platform/Drivers/irq/: wm_irq.c
    packages/wm_libraries-latest/rtthread/: rtthread_patch.c
    packages/wm_libraries-latest/Platform/Drivers/io/: wm_io.c
    packages/wm_libraries-latest/Platform/Common/crypto/: wm_crypto_hard.c
    packages/wm_libraries-latest/Platform/Drivers/pmu/: wm_pmu.c
    packages/wm_libraries-latest/Platform/Drivers/flash/: wm_fls.c wm_fls_gd25qxx.c
    packages/wm_libraries-latest/Platform/Drivers/adc/: wm_adc.c
    packages/wm_libraries-latest/Platform/Drivers/watchdog/: wm_watchdog.c
    packages/wm_libraries-latest/Platform/Common/Params/: wm_param.c
    packages/wm_libraries-latest/rtthread/utils/: utils.c
    packages/wm_libraries-latest/Platform/Common/crypto/math/: pstm_mul_comba.c
    packages/wm_libraries-latest/rtthread/startup/iar/: startup_venus.S
  group lwIP
    ../../components/net/lwip-dhcpd/: dhcp_server_raw.c
    ../../components/net/lwip/lwip-2.0.3/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../components/net/lwip/lwip-2.0.3/src/apps/ping/: ping.c
    ../../components/net/lwip/lwip-2.0.3/src/core/: def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../components/net/lwip/lwip-2.0.3/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../components/net/lwip/lwip-2.0.3/src/netif/: ethernet.c lowpan6.c
    ../../components/net/lwip/port/: ethernetif.c sys_arch.c
  group NetUtils
    packages/netutils-latest/ntp/: ntp.c
  group oneshot
    oneshot/: oneshot.c
  group POSIX
    ../../components/libc/posix/io/poll/: poll.c select.c
  group SAL
    ../../components/net/netdev/src/: netdev.c netdev_ipaddr.c
    ../../components/net/sal/dfs_net/: dfs_net.c
    ../../components/net/sal/impl/: af_inet_lwip.c
    ../../components/net/sal/socket/: net_netdb.c net_sockets.c
    ../../components/net/sal/src/: sal_socket.c
  group Utilities
    ../../components/utilities/ulog/backend/: console_be.c
    ../../components/utilities/ulog/: ulog.c
