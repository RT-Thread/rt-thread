# Keil uVision project project.uvproj, settings and files
target rtthread-fm3 (ARM-ADS)
  device: MB9BF506R Fujitsu Semiconductors
  cpu: IRAM(0x20000000-0x20007FFF) IRAM2(0x1FFF8000-0x1FFFFFFF) IROM(0x00000000-0x0007FFFF) CLOCK(4000000) CPUTYPE("Cortex-M3")
  output: rtthread-stm32
  c flags: Optim=1
  c define: __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND
  c include: applications;.;libraries\Device\FUJISTU\MB9BF50x\Include;libraries\CMSIS\Include;..\..\libcpu\arm\common;..\..\libcpu\arm\cortex-m3;..\..\components\drivers\include;..\..\components\drivers\include;drivers;..\..\components\finsh;.;..\..\include;..\..\components\libc\compilers\common;..\..\components\libc\compilers\common\nogcc;..\..\examples\utest\testcases\kernel
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x1fff8000 size 0x8000
  group Applications
    applications/: application.c startup.c
  group CMSIS
    libraries/Device/FUJISTU/MB9BF50x/Source/ARM/: startup_mb9bf50x.S
    libraries/Device/FUJISTU/MB9BF50x/Source/: system_mb9bf50x.c
  group CPU
    ../../libcpu/arm/common/: showmem.c backtrace.c div0.c
    ../../libcpu/arm/cortex-m3/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/src/: ringblk_buf.c workqueue.c pipe.c waitqueue.c dataqueue.c ringbuffer.c completion.c
  group Drivers
    drivers/: led.c fm3_uart.c nand.c board.c
  group Finsh
    ../../components/finsh/: shell.c msh.c
  group Kernel
    ../../src/: scheduler.c mem.c timer.c idle.c memheap.c irq.c object.c mempool.c components.c clock.c thread.c kservice.c device.c ipc.c
