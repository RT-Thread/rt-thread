# Keil uVision project project.uvprojx, settings and files
target rtthread (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: TAE32F5300 Tai-Action
  pack: Tai-Action.TAE32F53xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x4000) IRAM2(0x20004000,0x1000) IRAM3(0x20005000,0x1000) IROM(0x08000000,0x12c00) IROM2(0x18000000,0x4000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rtthread +hex
  AfterMake: .\AfterBuildHandler.bat $J #L
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: USE_TAE_DRIVER, TAE32F53xx, __CLK_TCK=RT_TICK_PER_SECOND, RT_USING_ARMLIBC, RT_USING_LIBC, __STDC_LIMIT_MACROS, __RTTHREAD__, __DEBUG
  c include: ..\..\components\libc\compilers\common\include;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\drivers\phy;..\..\components\finsh;..\..\libcpu\arm\cortex-m3;board;..\..\components\libc\compilers\common\extension\fcntl\octal;libraries\TAE32F53xx_StdPeriph_Driver\inc;..\..\components\net\utest;libraries\CMSIS\Device\Tai_action\TAE32F53xx\Include;libraries\CMSIS\Include;..\..\libcpu\arm\common;..\..\components\libc\compilers\common\extension;drivers;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\libc\posix\io\epoll;..\..\components\drivers\include;..\..\components\drivers\smp_call;..\..\components\libc\posix\io\eventfd;..\..\include;application;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\libc\posix\ipc;..\..\components\libc\posix\io\poll;.
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x12c00
  memory RVCT5: ROM 0x18000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x4000
  memory RVCT10: RAM 0x20004000 size 0x1000
  scatter file: .\board\linker_scripts\tae32f53xx_ac5_flash.sct
  group Applications
    application/: main.c
  group Board
    board/: board.c tae32f53xx_ll_msp.c
  group CPU
    ../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../libcpu/arm/cortex-m3/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../components/drivers/core/: device.c
    ../../components/drivers/i2c/: dev_i2c_bit_ops.c dev_i2c_core.c dev_i2c_dev.c
    ../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../components/drivers/pin/: dev_pin.c
    ../../components/drivers/serial/: dev_serial.c
  group Drivers
    drivers/: drv_uart.c drv_gpio.c
  group Finsh
    ../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group Libc
    ../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
  group TAE32_StdPeriph
    libraries/CMSIS/Device/Tai_action/TAE32F53xx/Source/: system_tae32f53xx.c startup_tae32f53xx.c
    libraries/TAE32F53xx_StdPeriph_Driver/src/: tae32f53xx_ll.c tae32f53xx_ll_cortex.c tae32f53xx_ll_sysctrl.c tae32f53xx_ll_fpll.c tae32f53xx_ll_gpio.c tae32f53xx_ll_dma.c tae32f53xx_ll_uart.c tae32f53xx_ll_tmr.c tae32f53xx_ll_i2c.c
