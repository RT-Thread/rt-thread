# Keil uVision project project.uvprojx, settings and files
target hc32f480 (5060020::V5.06 (build 20)::ARMCC)
  device: HC32F480RGTB HDSC
  pack: HDSC.HC32F480.1.0.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") CLOCK(12000000) ESEL ELITTLE
  output: hc32f480 +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 uC99=1
  c define: RT_USING_ARM_LIBC, USE_STDPERIPH_DRIVER
  c include: applications;.;drivers;libraries\peripheral\inc;libraries\mcu\common;libraries\cmsis\include;packages\CmBacktrace-v1.2.0;packages\EasyLogger-2.0.0\inc;packages\LittlevGL2RTT-latest;packages\LittlevGL2RTT-latest\lvgl;packages\LittlevGL2RTT-latest\lvgl\lv_core;packages\LittlevGL2RTT-latest\lvgl\lv_draw;packages\LittlevGL2RTT-latest\lvgl\lv_hal;packages\LittlevGL2RTT-latest\lvgl\lv_misc;packages\LittlevGL2RTT-latest\lvgl\lv_misc\lv_fonts;packages\LittlevGL2RTT-latest\lvgl\lv_objx;packages\LittlevGL2RTT-latest\lvgl\lv_themes;packages\LittlevGL2RTT-latest\example;..\..\include;..\..\libcpu\arm\cortex-m4;..\..\libcpu\arm\common;..\..\components\dfs\include;..\..\components\dfs\filesystems\devfs;..\..\components\dfs\filesystems\elmfat;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\finsh;..\..\components\libc\compilers\armlibc
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff8000 size 0x7fff
  memory RVCT10: RAM 0x20000000 size 0x1ffff
  link misc: --keep *.o(.rti_fn.*)   --keep *.o(FSymTab)
  group Applications
    applications/: application.c
  group Drivers
    drivers/: board.c drv_usart.c hw_delay.c sysram.c drv_lcd.c
  group HC32F480_StdPeriph
    libraries/mcu/common/: system_hc32f480.c
    libraries/peripheral/src/: clk.c ddl.c dmac.c exint.c exmc.c gpio.c i2c.c icg.c interrupts_hc32f480.c msc.c rtc.c spi.c swdt.c timer0.c timer2.c usart.c wdt.c
    libraries/mcu/MDK/: startup_hc32f480.s
  group cm_backtrace
    packages/CmBacktrace-v1.2.0/: cm_backtrace.c cmb_port.c
  group LittlevGL2RTT
    packages/LittlevGL2RTT-latest/: littlevgl2rtt.c
    packages/LittlevGL2RTT-latest/lvgl/lv_core/: lv_group.c lv_indev.c lv_obj.c lv_refr.c lv_style.c lv_vdb.c
    packages/LittlevGL2RTT-latest/lvgl/lv_draw/: lv_draw.c lv_draw_rbasic.c lv_draw_vbasic.c
    packages/LittlevGL2RTT-latest/lvgl/lv_hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
    packages/LittlevGL2RTT-latest/lvgl/lv_misc/: lv_anim.c lv_area.c lv_circ.c lv_color.c lv_font.c lv_fs.c lv_ll.c lv_math.c lv_mem.c lv_task.c lv_templ.c lv_trigo.c lv_txt.c lv_ufs.c
    packages/LittlevGL2RTT-latest/lvgl/lv_misc/lv_fonts/: lv_font_dejavu_10.c lv_font_dejavu_10_cyrillic.c lv_font_dejavu_10_latin_sup.c lv_font_dejavu_20.c lv_font_dejavu_20_cyrillic.c lv_font_dejavu_20_latin_sup.c lv_font_dejavu_30.c lv_font_dejavu_30_cyrillic.c lv_font_dejavu_30_latin_sup.c lv_font_dejavu_40.c lv_font_dejavu_40_cyrillic.c lv_font_dejavu_40_latin_sup.c lv_font_symbol_10.c lv_font_symbol_20.c lv_font_symbol_30.c lv_font_symbol_40.c
    packages/LittlevGL2RTT-latest/lvgl/lv_objx/: lv_bar.c lv_btn.c lv_btnm.c lv_cb.c lv_chart.c lv_cont.c lv_ddlist.c lv_gauge.c lv_img.c lv_kb.c lv_label.c lv_led.c lv_line.c lv_list.c lv_lmeter.c lv_mbox.c lv_objx_templ.c lv_page.c lv_roller.c lv_slider.c lv_sw.c lv_ta.c lv_tabview.c lv_win.c
    packages/LittlevGL2RTT-latest/lvgl/lv_themes/: lv_theme.c lv_theme_alien.c lv_theme_default.c lv_theme_material.c lv_theme_mono.c lv_theme_night.c lv_theme_templ.c lv_theme_zen.c
  group LittlevGL2RTT_Demo
    packages/LittlevGL2RTT-latest/example/: littlevgl2rtt_demo.c lv_test_theme.c
  group Kernel
    ../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group CORTEX-M4
    ../../libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
  group Filesystem
    ../../components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c poll.c select.c
    ../../components/dfs/filesystems/devfs/: devfs.c
    ../../components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
  group DeviceDrivers
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/src/: completion.c dataqueue.c pipe.c ringbuffer.c waitqueue.c workqueue.c
  group finsh
    ../../components/finsh/: shell.c symbol.c cmd.c msh.c msh_cmd.c msh_file.c
  group libc
    ../../components/libc/compilers/armlibc/: libc.c libc_syms.c mem_std.c stdio.c stubs.c time.c
