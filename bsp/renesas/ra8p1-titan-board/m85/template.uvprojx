# Keil uVision project template.uvprojx, settings and files
target Target_1 (6190000::V6.19::ARMCLANG)
  device: R7KA8P1KF:CPU0 Renesas
  pack: Renesas.RA_DFP.6.1.0
  cpu: CPUTYPE("Cortex-M85") DSP TZ MVE(FP) FPU3(DFPU) PACBTI CLOCK(12000000) ELITTLE
  output: template +hex
  AfterMake: cmd /c ""$Prasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --gensmartbundle --compiler ARMv6 --devicefamily ra "$Pconfiguration.xml" "$L%L" 2> "$PObjects\rasc_stderr.out""
  c flags: v6Lang=3 v6LangP=6
  scatter file: .\script\fsp.scat
  link misc: --entry=Reset_Handler --no_startup
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_entry.c
software components: Flex Software:RA Configuration 1.0.0
