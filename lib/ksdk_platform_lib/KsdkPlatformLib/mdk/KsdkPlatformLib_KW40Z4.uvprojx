# Keil uVision project KsdkPlatformLib_KW40Z4.uvprojx, settings and files
target KsdkPlatformLib_KW40Z4 Debug (ARM-ADS)
  device: MKW40Z160xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.1.0
  cpu: CPUTYPE("Cortex-M0plus")
  output: libksdk_platform.lib (library)
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: DEBUG, CPU_MKW40Z160VHT4, FRDM_KW40Z, FREEDOM
  c misc: --diag_suppress=66
  c include: ../../../../bsp/freescale/platform/osa/inc;../../../../bsp/freescale/platform/CMSIS/Include;../../../../bsp/freescale/platform/devices;../../../../bsp/freescale/platform/devices/MKW40Z4/include;../../../../bsp/freescale/platform/devices/MKW40Z4/startup;../../../../bsp/freescale/platform/utilities/inc;../../../../bsp/freescale/platform/hal/inc;../../../../bsp/freescale/platform/drivers/inc;../../../../bsp/freescale/platform/system/inc;../../../../components/drivers/include/drivers;../../../../components/drivers/include;../../../../bsp/freescale/driver_wrapper/inc;../../../../components/finsh;../../../../include
  asm define: DEBUG
  asm misc: --cpreproc_opts '-DDEBUG'
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x600
  memory RVCT10: RAM 0x1ffffe00 size 0x200
  group osa
    ../../../../bsp/freescale/platform/osa/inc/: fsl_os_abstraction.h fsl_os_abstraction_bm.h
    ../../../../bsp/freescale/platform/osa/src/: fsl_os_abstraction_bm.c
  group platform-clock-system
    ../../../../bsp/freescale/platform/system/src/clock/: fsl_clock_manager.c fsl_clock_manager_common.c
    ../../../../bsp/freescale/platform/system/inc/: fsl_clock_manager.h
    ../../../../bsp/freescale/platform/system/src/clock/MKW40Z4/: fsl_clock_MKW40Z4.c fsl_clock_MKW40Z4.h
  group platform-interrupt-system
    ../../../../bsp/freescale/platform/system/src/interrupt/: fsl_interrupt_manager.c
    ../../../../bsp/freescale/platform/system/inc/: fsl_interrupt_manager.h
  group platform-hwtimer-system
    ../../../../bsp/freescale/platform/system/src/hwtimer/: fsl_hwtimer.c fsl_hwtimer_pit.c fsl_hwtimer_systick.c
    ../../../../bsp/freescale/platform/system/inc/: fsl_hwtimer.h fsl_hwtimer_pit.h fsl_hwtimer_systick.h
  group platform-power-system
    ../../../../bsp/freescale/platform/system/src/power/: fsl_power_manager.c fsl_power_manager_common.h
    ../../../../bsp/freescale/platform/system/inc/: fsl_power_manager.h
  group platform-adc16-hal
    ../../../../bsp/freescale/platform/hal/src/adc16/: fsl_adc16_hal.c
    ../../../../bsp/freescale/platform/hal/inc/: fsl_adc16_hal.h
  group platform-adc16-drivers
    ../../../../bsp/freescale/platform/drivers/inc/: fsl_adc16_driver.h
    ../../../../bsp/freescale/platform/drivers/src/adc16/: fsl_adc16_driver.c fsl_adc16_common.c
  group platform-cmp-hal
    ../../../../bsp/freescale/platform/hal/src/cmp/: fsl_cmp_hal.c
    ../../../../bsp/freescale/platform/hal/inc/: fsl_cmp_hal.h
  group platform-cmp-drivers
    ../../../../bsp/freescale/platform/drivers/src/cmp/: fsl_cmp_driver.c fsl_cmp_common.c
    ../../../../bsp/freescale/platform/drivers/inc/: fsl_cmp_driver.h
  group platform-cmt-hal
    ../../../../bsp/freescale/platform/hal/src/cmt/: fsl_cmt_hal.c
    ../../../../bsp/freescale/platform/hal/inc/: fsl_cmt_hal.h
  group platform-cmt-drivers
    ../../../../bsp/freescale/platform/drivers/src/cmt/: fsl_cmt_driver.c fsl_cmt_common.c
    ../../../../bsp/freescale/platform/drivers/inc/: fsl_cmt_driver.h
  group platform-cop-hal
    ../../../../bsp/freescale/platform/hal/src/cop/: fsl_cop_hal.c
    ../../../../bsp/freescale/platform/hal/inc/: fsl_cop_hal.h
  group platform-cop-drivers
    ../../../../bsp/freescale/platform/drivers/src/cop/: fsl_cop_driver.c fsl_cop_common.c
    ../../../../bsp/freescale/platform/drivers/inc/: fsl_cop_driver.h
  group platform-dac-hal
    ../../../../bsp/freescale/platform/hal/src/dac/: fsl_dac_hal.c
    ../../../../bsp/freescale/platform/hal/inc/: fsl_dac_hal.h
  group platform-dac-drivers
    ../../../../bsp/freescale/platform/drivers/src/dac/: fsl_dac_driver.c fsl_dac_common.c
    ../../../../bsp/freescale/platform/drivers/inc/: fsl_dac_driver.h
  group platform-dma-hal
    ../../../../bsp/freescale/platform/hal/src/dma/: fsl_dma_hal.c
    ../../../../bsp/freescale/platform/hal/inc/: fsl_dma_hal.h
  group platform-dma-drivers
    ../../../../bsp/freescale/platform/drivers/src/dma/: fsl_dma_driver.c fsl_dma_common.c
    ../../../../bsp/freescale/platform/drivers/inc/: fsl_dma_driver.h fsl_dma_request.h
  group platform-dmamux-hal
    ../../../../bsp/freescale/platform/hal/src/dmamux/: fsl_dmamux_hal.c
    ../../../../bsp/freescale/platform/hal/inc/: fsl_dmamux_hal.h
  group platform-dspi-hal
    ../../../../bsp/freescale/platform/hal/src/dspi/: fsl_dspi_hal.c
    ../../../../bsp/freescale/platform/hal/inc/: fsl_dspi_hal.h
  group platform-dspi-drivers
    ../../../../bsp/freescale/platform/drivers/src/dspi/: fsl_dspi_shared_function.c fsl_dspi_common.c
    ../../../../bsp/freescale/platform/drivers/inc/: fsl_dspi_shared_function.h
  group platform-dspi-drivers-master
    ../../../../bsp/freescale/platform/drivers/inc/: fsl_dspi_master_driver.h fsl_dspi_dma_master_driver.h
    ../../../../bsp/freescale/platform/drivers/src/dspi/: fsl_dspi_master_driver.c fsl_dspi_dma_master_driver.c
  group platform-dspi-drivers-slave
    ../../../../bsp/freescale/platform/drivers/inc/: fsl_dspi_slave_driver.h fsl_dspi_dma_slave_driver.h
    ../../../../bsp/freescale/platform/drivers/src/dspi/: fsl_dspi_slave_driver.c fsl_dspi_dma_slave_driver.c
  group platform-gpio-hal
    ../../../../bsp/freescale/platform/hal/src/gpio/: fsl_gpio_hal.c
    ../../../../bsp/freescale/platform/hal/inc/: fsl_gpio_hal.h
  group platform-gpio-drivers
    ../../../../bsp/freescale/platform/drivers/src/gpio/: fsl_gpio_common.c fsl_gpio_driver.c
    ../../../../bsp/freescale/platform/drivers/inc/: fsl_gpio_driver.h
  group platform-i2c-hal
    ../../../../bsp/freescale/platform/hal/src/i2c/: fsl_i2c_hal.c
    ../../../../bsp/freescale/platform/hal/inc/: fsl_i2c_hal.h
  group platform-i2c-drivers
    ../../../../bsp/freescale/platform/drivers/src/i2c/: fsl_i2c_shared_function.c fsl_i2c_common.c
    ../../../../bsp/freescale/platform/drivers/inc/: fsl_i2c_shared_function.h
  group platform-i2c-drivers-master
    ../../../../bsp/freescale/platform/drivers/src/i2c/: fsl_i2c_master_driver.c
    ../../../../bsp/freescale/platform/drivers/inc/: fsl_i2c_master_driver.h
  group platform-i2c-drivers-slave
    ../../../../bsp/freescale/platform/drivers/src/i2c/: fsl_i2c_slave_driver.c
    ../../../../bsp/freescale/platform/drivers/inc/: fsl_i2c_slave_driver.h
  group platform-llwu-hal
    ../../../../bsp/freescale/platform/hal/src/llwu/: fsl_llwu_hal.c
    ../../../../bsp/freescale/platform/hal/inc/: fsl_llwu_hal.h
  group platform-lptmr-hal
    ../../../../bsp/freescale/platform/hal/src/lptmr/: fsl_lptmr_hal.c
    ../../../../bsp/freescale/platform/hal/inc/: fsl_lptmr_hal.h
  group platform-lptmr-drivers
    ../../../../bsp/freescale/platform/drivers/inc/: fsl_lptmr_driver.h
    ../../../../bsp/freescale/platform/drivers/src/lptmr/: fsl_lptmr_driver.c fsl_lptmr_common.c
  group platform-ltc-hal
    ../../../../bsp/freescale/platform/hal/src/ltc/: fsl_ltc_hal.c
    ../../../../bsp/freescale/platform/hal/inc/: fsl_ltc_hal.h
  group platform-ltc-drivers
    ../../../../bsp/freescale/platform/drivers/inc/: fsl_ltc_driver.h fsl_ltc_driver_aes.h fsl_ltc_driver_hash.h fsl_ltc_driver_prv.h
    ../../../../bsp/freescale/platform/drivers/src/ltc/: fsl_ltc_driver.c fsl_ltc_driver_aes.c fsl_ltc_driver_aes_ccm.c fsl_ltc_driver_hash.c fsl_ltc_common.c
  group platform-trng-hal
    ../../../../bsp/freescale/platform/hal/src/trng/: fsl_trng_hal.c
    ../../../../bsp/freescale/platform/hal/inc/: fsl_trng_hal.h
  group platform-trng-drivers
    ../../../../bsp/freescale/platform/drivers/src/trng/: fsl_trng_common.c fsl_trng_driver.c
    ../../../../bsp/freescale/platform/drivers/inc/: fsl_trng_driver.h
  group platform-lpuart-hal
    ../../../../bsp/freescale/platform/hal/src/lpuart/: fsl_lpuart_hal.c
    ../../../../bsp/freescale/platform/hal/inc/: fsl_lpuart_hal.h
  group platform-lpuart-drivers
    ../../../../bsp/freescale/platform/drivers/inc/: fsl_lpuart_driver.h fsl_lpuart_dma_driver.h
    ../../../../bsp/freescale/platform/drivers/src/lpuart/: fsl_lpuart_driver.c fsl_lpuart_common.c fsl_lpuart_dma_driver.c
  group platform-mcg-hal
    ../../../../bsp/freescale/platform/hal/src/mcg/: fsl_mcg_hal.c fsl_mcg_hal_modes.c
    ../../../../bsp/freescale/platform/hal/inc/: fsl_mcg_hal.h fsl_mcg_hal_modes.h
  group platform-pit-hal
    ../../../../bsp/freescale/platform/hal/src/pit/: fsl_pit_hal.c
    ../../../../bsp/freescale/platform/hal/inc/: fsl_pit_hal.h
  group platform-pit-drivers
    ../../../../bsp/freescale/platform/drivers/src/pit/: fsl_pit_driver.c fsl_pit_common.c
    ../../../../bsp/freescale/platform/drivers/inc/: fsl_pit_driver.h
  group platform-port-hal
    ../../../../bsp/freescale/platform/hal/src/port/: fsl_port_hal.c
    ../../../../bsp/freescale/platform/hal/inc/: fsl_port_hal.h
  group platform-rtc-hal
    ../../../../bsp/freescale/platform/hal/src/rtc/: fsl_rtc_hal.c
    ../../../../bsp/freescale/platform/hal/inc/: fsl_rtc_hal.h
  group platform-rtc-drivers
    ../../../../bsp/freescale/platform/drivers/src/rtc/: fsl_rtc_driver.c fsl_rtc_common.c
    ../../../../bsp/freescale/platform/drivers/inc/: fsl_rtc_driver.h
  group platform-sim-hal
    ../../../../bsp/freescale/platform/hal/inc/: fsl_sim_hal.h
    ../../../../bsp/freescale/platform/hal/src/sim/MKW40Z4/: fsl_sim_hal_MKW40Z4.c fsl_sim_hal_MKW40Z4.h
  group platform-smc-hal
    ../../../../bsp/freescale/platform/hal/src/smc/: fsl_smc_hal.c
    ../../../../bsp/freescale/platform/hal/inc/: fsl_smc_hal.h
  group platform-pmc-hal
    ../../../../bsp/freescale/platform/hal/inc/: fsl_pmc_hal.h
  group platform-rcm-hal
    ../../../../bsp/freescale/platform/hal/src/rcm/: fsl_rcm_hal.c
    ../../../../bsp/freescale/platform/hal/inc/: fsl_rcm_hal.h
  group platform-tpm-hal
    ../../../../bsp/freescale/platform/hal/inc/: fsl_tpm_hal.h
    ../../../../bsp/freescale/platform/hal/src/tpm/: fsl_tpm_hal.c
  group platform-tpm-drivers
    ../../../../bsp/freescale/platform/drivers/src/tpm/: fsl_tpm_common.c fsl_tpm_driver.c
    ../../../../bsp/freescale/platform/drivers/inc/: fsl_tpm_driver.h
  group platform-tsi-hal
    ../../../../bsp/freescale/platform/hal/src/tsi/: fsl_tsi_hal.c fsl_tsi_v4_hal_specific.c
    ../../../../bsp/freescale/platform/hal/inc/: fsl_tsi_hal.h fsl_tsi_v4_hal_specific.h
  group platform-tsi-drivers
    ../../../../bsp/freescale/platform/drivers/src/tsi/: fsl_tsi_common.c fsl_tsi_driver.c fsl_tsi_v4_driver_specific.c
    ../../../../bsp/freescale/platform/drivers/inc/: fsl_tsi_driver.h
target KsdkPlatformLib_KW40Z4 Release (ARM-ADS)
  device: MKW40Z160xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.1.0
  cpu: CPUTYPE("Cortex-M0plus")
  output: libksdk_platform.lib (library)
  c flags: Optim=4 OneElfS=1
  c define: NDEBUG, CPU_MKW40Z160VHT4, FRDM_KW40Z, FREEDOM
  c misc: --diag_suppress=66
  c include: as above
  asm define: NDEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x600
  memory RVCT10: RAM 0x1ffffe00 size 0x200
