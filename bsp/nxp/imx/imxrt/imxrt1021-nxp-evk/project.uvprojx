# Keil uVision project project.uvprojx, settings and files
target rtthread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MIMXRT1021DAG5A NXP
  pack: NXP.MIMXRT1021_DFP.16.0.0
  cpu: IRAM(0x20000000,0x010000) IRAM2(0x00000000,0x010000) XRAM(0x20200000,0x020000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL, __STDC_LIMIT_MACROS, EVK_MCIMXRM, RT_USING_ARMLIBC, STD=C99, XIP_EXTERNAL_FLASH=1, __FPU_PRESENT=1, CPU_MIMXRT1021DAG5A, __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND, XIP_BOOT_HEADER_ENABLE=1, RT_USING_LIBC, SKIP_SYSCLK_INIT, ENDIANNESS
  c misc: -fno-common  -fdata-sections  -ffreestanding  -fno-builtin  -mthumb
  c include: ..\..\..\..\..\components\drivers\sdio\sdhci\include;..\..\..\..\..\libcpu\arm\common;..\..\..\..\..\components\dfs\dfs_v1\filesystems\devfs;xip;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\drivers\include;..\..\..\..\..\include;..\libraries\MIMXRT1020\MIMXRT1021;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\libc\posix\io\eventfd;..\..\..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\..\..\components\libc\posix\io\epoll;..\..\..\..\..\components\dfs\dfs_v1\filesystems\elmfat;..\..\..\..\..\components\drivers\include;..\libraries\MIMXRT1020\MIMXRT1021\drivers;..\..\..\..\..\components\drivers\phy;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\drivers\spi;..\..\..\..\..\libcpu\arm\cortex-m7;..\..\..\..\..\components\dfs\dfs_v1\include;.;..\..\..\..\..\components\legacy\usb\usbdevice;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\libc\compilers\common\include;..\..\..\..\..\components\drivers\include;..\libraries\MIMXRT1020\CMSIS\Include;..\..\..\..\..\components\libc\compilers\common\extension;..\..\..\..\..\components\drivers\include;board;..\..\..\..\..\components\finsh;..\..\..\..\..\components\drivers\smp_call;..\..\..\..\..\components\libc\posix\ipc;..\..\..\..\..\components\libc\posix\io\poll;applications;..\..\..\..\..\components\drivers\include;board\ports;board\MCUX_Config;..\libraries\drivers
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  memory RVCT1: ROM 0x60000000 size 0x800000
  memory RVCT6: RAM 0x20200000 size 0x20000
  memory RVCT9: RAM 0x0 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
  link misc: --keep=*(.boot_hdr.ivt)--keep=*(.boot_hdr.boot_data)--keep=*(.boot_hdr.dcd_data)--keep=*(.boot_hdr.conf)
  group Applications
    applications/: main.c
  group Compiler
    ../../../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../../../components/drivers/core/: device.c
    ../../../../../components/drivers/i2c/: dev_i2c_bit_ops.c dev_i2c_core.c dev_i2c_dev.c
    ../../../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../../components/drivers/misc/: adc.c rt_drv_pwm.c
    ../../../../../components/drivers/pin/: dev_pin.c
    ../../../../../components/drivers/rtc/: dev_rtc.c
    ../../../../../components/drivers/sdio/: dev_block.c dev_mmc.c dev_mmcsd_core.c dev_sd.c dev_sdio.c
    ../../../../../components/drivers/serial/: dev_serial.c
    ../../../../../components/drivers/spi/: dev_qspi_core.c dev_spi.c dev_spi_core.c
  group Drivers
    board/MCUX_Config/: clock_config.c dcd.c pin_mux.c
    board/: board.c
    ../libraries/drivers/: drv_common.c drv_gpio.c drv_uart.c
  group Filesystem
    ../../../../../components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    ../../../../../components/dfs/dfs_v1/filesystems/elmfat/: dfs_elm.c ff.c ffunicode.c
    ../../../../../components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    ../../../../../components/finsh/: msh_file.c msh_parse.c shell.c cmd.c msh.c
  group Kernel
    ../../../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    ../../../../../src/klibc/: rt_vsscanf.c kstdio.c kstring.c rt_vsnprintf_tiny.c kerrno.c
  group libcpu
    ../../../../../libcpu/arm/common/: div0.c showmem.c
    ../../../../../libcpu/arm/cortex-m7/: context_rvds.S cpu_cache.c cpuport.c
  group Libraries
    ../libraries/MIMXRT1020/MIMXRT1021/drivers/: fsl_cache.c fsl_lpuart.c fsl_clock.c fsl_gpio.c fsl_usdhc.c fsl_common.c
    ../libraries/MIMXRT1020/MIMXRT1021/: system_MIMXRT1021.c
    ../libraries/MIMXRT1020/MIMXRT1021/arm/: startup_MIMXRT1021.s
  group rt_usbd
    ../../../../../components/legacy/usb/usbdevice/class/: cdc_vcom.c mstorage.c
    ../../../../../components/legacy/usb/usbdevice/core/: usbdevice_core.c usbdevice.c
  group xip
    xip/: fsl_flexspi_nor_boot.c fsl_flexspi_nor_flash.c
