# Keil uVision project project.uvprojx, settings and files
target nv32f100x (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: NV32F100FS16E Navota MCU
  pack: Keil.NV32F100_DFP.1.0
  cpu: IRAM(0x1FFFF800,0x2000) IROM(0x00000000,0x20000) IROM2(0x00400000,0x1400) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: nv32f100x
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: NV32, KEIL
  c include: board/inc;app/inc;.;lib/inc;../../include;../../libcpu/arm/cortex-m0;../../libcpu/arm/common;../../components/drivers/include;../../components/drivers/include;../../components/drivers/spi;../../components/drivers/include;../../components/drivers/include;../../components/finsh
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x1400
  memory RVCT9: RAM 0x1ffff800 size 0x2000
  link misc: --keep *.o(.rti_fn.*)   --keep *.o(FSymTab)
  group Drivers
    board/src/: board.c drv_uart.c start.c sysinit.c
  group Applications
    app/src/: ledapp.c main.c
  group Lib
    lib/src/: acmp.c adc.c arm_cm0.c crc.c eeprom.c etm.c flash.c gpio.c i2c.c ics.c kbi.c pit.c pmc.c rtc.c sim.c spi.c uart.c wdog.c startup_NV32.s
  group Kernel
    ../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c object.c scheduler.c signal.c thread.c timer.c
  group CORTEX-M0
    ../../libcpu/arm/cortex-m0/: cpuport.c context_rvds.S
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
  group DeviceDrivers
    ../../components/drivers/misc/: pin.c
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/spi/: spi_core.c spi_dev.c
    ../../components/drivers/src/: completion.c dataqueue.c pipe.c ringbuffer.c waitqueue.c workqueue.c
  group finsh
    ../../components/finsh/: shell.c symbol.c cmd.c msh.c msh_cmd.c msh_file.c
