# Keil uVision project project.uvproj, settings and files
target rt-thread (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: RT_USING_ARMLIBC, __RTTHREAD__, __STDC_LIMIT_MACROS, __MSP432E401Y__, RT_USING_LIBC, rvmdk, __CLK_TCK=RT_TICK_PER_SECOND
  c include: ..\..\libcpu\arm\common;libraries\Drivers\config;..\..\libcpu\arm\cortex-m4;..\..\components\libc\posix\ipc;libraries\msp432e4\driverlib\inc;board;..\..\components\libc\compilers\common\include;applications;..\..\components\finsh;..\..\components\drivers\include;..\..\components\drivers\include;..\..\include;..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\components\libc\compilers\common\extension;..\..\components\drivers\include;..\..\components\drivers\phy;..\..\components\libc\posix\io\eventfd;libraries\msp432e4\inc;..\..\components\libc\posix\io\poll;libraries\msp432e4\driverlib;..\..\components\drivers\include;..\..\components\drivers\smp_call;..\..\components\drivers\include;..\..\components\libc\posix\io\epoll;libraries\Drivers\CMSIS\Include;.;libraries\Drivers;..\..\components\drivers\include;..\..\components\net\utest
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group CPU
    ../../libcpu/arm/common/: div0.c showmem.c
    ../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../components/drivers/core/: device.c
    ../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../components/drivers/pin/: dev_pin.c
    ../../components/drivers/serial/: dev_serial.c
  group Drivers
    board/: board.c
    libraries/msp432e4/startup_system_files/keil/: startup_msp432e401y_uvision.s
    libraries/Drivers/: drv_gpio.c drv_uart.c
  group Finsh
    ../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group Libc
    ../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
  group Libraries
    libraries/msp432e4/startup_system_files/: system_msp432e401y.c
    libraries/msp432e4/driverlib/: sysctl.c systick.c interrupt.c fpu.c cpu.c gpio.c uart.c
