# Keil uVision project project.uvprojx, settings and files
target Target 1 (6150000::V6.15::ARMCLANG)
  device: GD32F103RC GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.2
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: gd32f103 +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: RT_USING_ARM_LIBC, __RTTHREAD__
  c include: applications;..\..\libcpu\arm\common;..\..\libcpu\arm\cortex-m3;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\drivers\include;drivers;drivers\ports;packages\EasyFlash-v4.1.0\inc;packages\fal-v0.5.0\inc;..\..\components\finsh;.;..\..\include;..\..\components\libc\compilers\armlibc;..\..\components\libc\compilers\common
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Applications
    applications/: main.c
  group cpu
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
  group DeviceDrivers
    ../../components/drivers/misc/: pin.c
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
  group Drivers
    drivers/: board.c drv_usart.c drv_flash.c
    drivers/ports/: fal_flash_gd32f1_port.c ef_fal_port.c
  group EasyFlash
    packages/EasyFlash-v4.1.0/src/: easyflash.c ef_cmd.c ef_env.c ef_env_legacy.c ef_env_legacy_wl.c ef_iap.c ef_log.c ef_utils.c
  group fal
    packages/fal-v0.5.0/src/: fal.c fal_flash.c fal_partition.c fal_rtt.c
  group finsh
    ../../components/finsh/: shell.c cmd.c msh.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_var.c finsh_vm.c finsh_token.c
  group Kernel
    ../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group libc
    ../../components/libc/compilers/armlibc/: libc.c mem_std.c stubs.c
    ../../components/libc/compilers/common/: time.c
software components: CMSIS:CORE 5.4.0, Device:GD32F10x_StdPeripherals:FMC 2.0.1, Device:GD32F10x_StdPeripherals:GPIO 2.0.1, Device:GD32F10x_StdPeripherals:MISC 2.0.1, Device:GD32F10x_StdPeripherals:PMU 2.0.1, Device:GD32F10x_StdPeripherals:RCU 2.0.1, Device:GD32F10x_StdPeripherals:USART 2.0.1, Device:GD32F10x_libopt 2.0.1, Device:Startup 2.0.1
