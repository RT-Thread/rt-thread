# Keil uVision project project.uvproj, settings and files
target rtthread-m480 (ARM-ADS)
  device: M487JIDAE Nuvoton
  cpu: IRAM(0x20000000-0x20027FFF) IROM(0-0x7FFFF) CLOCK(192000000) CPUTYPE("Cortex-M4") FPU2
  output: rtthread +hex
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1
  c define: RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND, __RTTHREAD__, __STDC_LIMIT_MACROS, RT_USING_ARMLIBC
  c misc: --c99
  c include: board\NuPinConfig;..\..\..\components\net\sal\impl;..\..\..\components\libc\compilers\common\extension;..\..\..\components\dfs\dfs_v1\filesystems\elmfat;..\..\..\components\drivers\smp_call;..\..\..\components\drivers\sdio\sdhci\include;..\..\..\components\libc\posix\io\eventfd;..\libraries\nu_packages\Demo;..\..\..\components\net\lwip\lwip-2.0.3\src\include\ipv4;board;..\..\..\components\drivers\include;..\..\..\components\utilities\utest;..\libraries\m480\USBHostLib\inc;applications;..\..\..\components\drivers\audio;..\libraries\nu_packages\AudioCodec;..\libraries\m480\CMSIS\Include;..\libraries\m480\Device\Nuvoton\M480\Include;..\libraries\m480\rtt_port;..\libraries\nu_packages\NuUtils\inc;..\..\..\components\net\sal\include\dfs_net;..\..\..\components\libc\posix\io\epoll;..\..\..\components\net\lwip\lwip-2.0.3\src\include\netif;..\..\..\components\drivers\include;..\..\..\libcpu\arm\common;..\..\..\components\drivers\include;..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\libraries\nu_packages\TPC;..\..\..\libcpu\arm\cortex-m4;..\..\..\components\drivers\include;..\..\..\components\net\lwip\lwip-2.0.3\src\include;..\..\..\components\legacy\usb\usbhost\core;..\..\..\components\net\netdev\include;..\..\..\components\drivers\include;..\..\..\components\drivers\spi\sfud\inc;..\..\..\components\drivers\include;..\..\..\components\dfs\dfs_v1\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\dfs\dfs_v1\filesystems\devfs;..\..\..\components\drivers\include;.;..\..\..\components\libc\posix\ipc;..\..\..\components\legacy\usb\usbhost;..\..\..\components\legacy\usb\usbhost\class;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\net\sal\include;..\..\..\components\libc\compilers\common\include;..\..\..\components\fal\inc;..\..\..\components\finsh;..\..\..\components\drivers\hwcrypto;..\..\..\include;..\..\..\components\drivers\include;..\..\..\components\net\lwip\port;..\..\..\components\drivers\include;..\..\..\components\net\sal\include\socket\sys_socket;..\libraries\m480\StdDriver\inc;..\..\..\components\drivers\spi;..\..\..\components\drivers\phy;..\..\..\components\legacy\usb\usbdevice;..\..\..\components\net\sal\include\socket;..\..\..\components\legacy\usb\usbhost\include;..\..\..\components\libc\posix\io\poll;board\NuClockConfig;..\..\..\components\drivers\include;..\..\..\components\legacy\include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  scatter file: .\linking_scripts\m480_flash.sct
  group Applications
    applications/: mnt.c main.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../components/drivers/audio/: dev_audio.c dev_audio_pipe.c
    ../../../components/drivers/can/: dev_can.c
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/hwcrypto/: hw_crc.c hw_hash.c hw_rng.c hw_symmetric.c hwcrypto.c
    ../../../components/drivers/hwtimer/: hwtimer.c
    ../../../components/drivers/i2c/: dev_i2c_bit_ops.c dev_i2c_core.c dev_i2c_dev.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/misc/: adc.c rt_drv_pwm.c
    ../../../components/drivers/pin/: dev_pin.c
    ../../../components/drivers/pm/: lptimer.c pm.c
    ../../../components/drivers/rtc/: dev_rtc.c
    ../../../components/drivers/sdio/: dev_block.c dev_mmc.c dev_mmcsd_core.c dev_sd.c dev_sdio.c
    ../../../components/drivers/serial/: dev_serial.c
    ../../../components/drivers/spi/: dev_qspi_core.c dev_spi.c dev_spi_core.c dev_spi_flash_sfud.c
    ../../../components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    ../../../components/drivers/watchdog/: dev_watchdog.c
  group Drivers
    ../libraries/m480/Device/Nuvoton/M480/Source/ARM/: startup_M480.s
    ../libraries/m480/Device/Nuvoton/M480/Source/: system_M480.c
    board/NuClockConfig/: nutool_modclkcfg.c
    board/NuPinConfig/: nutool_pincfg.c
    board/: board_dev.c
    ../libraries/m480/rtt_port/: drv_bpwm.c drv_bpwm_capture.c drv_can.c drv_clk.c drv_common.c drv_crc.c drv_crypto.c drv_eadc.c drv_ebi.c drv_ecap.c drv_emac.c drv_epwm.c drv_epwm_capture.c drv_fmc.c drv_gpio.c drv_hsotg.c drv_hsusbd.c drv_i2c.c drv_i2s.c drv_pdma.c drv_qei.c drv_qspi.c drv_rtc.c drv_scuart.c drv_sdh.c drv_sdio.c drv_softi2c.c drv_spi.c drv_spii2s.c drv_timer.c drv_timer_capture.c drv_tpwm.c drv_trng.c drv_uart.c drv_ui2c.c drv_usbd.c drv_usbhost.c drv_uspi.c drv_uuart.c drv_wdt.c
  group Fal
    ../../../components/fal/src/: fal_partition.c fal_rtt.c fal.c fal_flash.c
  group Filesystem
    ../../../components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    ../../../components/dfs/dfs_v1/filesystems/elmfat/: dfs_elm.c ff.c ffunicode.c
    ../../../components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    ../../../components/finsh/: shell.c msh_file.c msh.c cmd.c msh_parse.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c signal.c thread.c timer.c
  group klibc
    ../../../src/klibc/: kerrno.c rt_vsnprintf_tiny.c rt_vsscanf.c kstdio.c kstring.c
  group libcpu
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group Libraries
    ../libraries/m480/StdDriver/src/: nu_emac.c nu_wwdt.c nu_timer.c nu_pdma.c nu_usci_uart.c nu_usci_i2c.c nu_gpio.c nu_sc.c nu_i2c.c nu_scuart.c nu_crypto.c nu_acmp.c nu_hsusbd.c nu_spim.c nu_wdt.c nu_crc.c nu_qspi.c nu_spi.c nu_i2s.c nu_qei.c nu_can.c nu_epwm.c nu_rtc.c nu_clk.c nu_eadc.c nu_trng.c nu_ebi.c nu_timer_pwm.c nu_ecap.c nu_usci_spi.c nu_sdh.c nu_ccap.c nu_dac.c nu_uart.c nu_sys.c nu_usbd.c nu_fmc.c nu_bpwm.c
  group lwIP
    ../../../components/net/lwip/lwip-2.0.3/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../components/net/lwip/lwip-2.0.3/src/apps/ping/: ping.c
    ../../../components/net/lwip/lwip-2.0.3/src/core/: def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../components/net/lwip/lwip-2.0.3/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../components/net/lwip/lwip-2.0.3/src/netif/: ethernet.c lowpan6.c
    ../../../components/net/lwip/port/: ethernetif.c sys_arch.c
  group m480_usbhostlib
    ../libraries/m480/USBHostLib/src/: mem_alloc.c ohci.c usb_core.c ehci.c ehci_iso.c
  group nu_pkgs_demo
    ../libraries/nu_packages/Demo/: slcd_show_tick.c atdev_utils.c hwsem_counter.c smp_demo.c usbd_hid_dance_mouse.c ccap_demo.c usbd_cdc_vcom_echo.c ccap_saver.c wormhole_demo.c
  group nu_pkgs_nau88l25
    ../libraries/nu_packages/AudioCodec/: acodec_nau88l25.c audio_test.c
  group rt_usbd
    ../../../components/legacy/usb/usbdevice/core/: usbdevice_core.c usbdevice.c
    ../../../components/legacy/usb/usbdevice/class/: hid.c
  group rt_usbh
    ../../../components/legacy/usb/usbhost/core/: hub.c usbhost_core.c driver.c usbhost.c
    ../../../components/legacy/usb/usbhost/class/: mass.c udisk.c
  group SAL
    ../../../components/net/netdev/src/: netdev.c netdev_ipaddr.c
    ../../../components/net/sal/dfs_net/: dfs_net.c
    ../../../components/net/sal/impl/: af_inet_lwip.c
    ../../../components/net/sal/socket/: net_netdb.c net_sockets.c
    ../../../components/net/sal/src/: sal_socket.c
  group UTest
    ../../../components/utilities/utest/: TC_uassert.c utest.c
