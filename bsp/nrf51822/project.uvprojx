# Keil uVision project project.uvprojx, settings and files
target rt-thread (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.38.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: template
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: NRF51, __RTTHREAD__, USE_STDPERIPH_DRIVER, __CLK_TCK=RT_TICK_PER_SECOND
  c misc: --c99
  c include: applications;.;..\..\libcpu\arm\common;..\..\libcpu\arm\cortex-m0;..\..\components\drivers\include;drivers;Libraries\CMSIS\Include;Libraries\nrf51822\Include;..\..\components\finsh;.;..\..\include;..\..\components\libc\compilers\common;..\..\components\libc\compilers\common\nogcc;..\..\examples\utest\testcases\kernel
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Applications
    applications/: application.c startup.c
  group CPU
    ../../libcpu/arm/common/: div0.c showmem.c backtrace.c
    ../../libcpu/arm/cortex-m0/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../components/drivers/src/: completion.c ringbuffer.c waitqueue.c workqueue.c dataqueue.c ringblk_buf.c pipe.c
  group Drivers
    drivers/: uart.c board.c
    Libraries/nrf51822/Source/templates/: system_nrf51.c
    Libraries/nrf51822/Source/templates/arm/: arm_startup_nrf51.s
  group Finsh
    ../../components/finsh/: shell.c msh.c
  group Kernel
    ../../src/: irq.c clock.c timer.c thread.c components.c mempool.c ipc.c object.c device.c kservice.c mem.c idle.c scheduler.c
