# Keil uVision project project.uvprojx, settings and files
target Target_1 (6180000::V6.18::ARMCLANG)
  device: R7FA2E2A7 Renesas
  pack: Renesas.RA_DFP.6.0.0
  cpu: CPUTYPE("Cortex-M23")      CLOCK(12000000) ELITTLE
  output: rtthread +hex
  c flags: v6Lang=3 v6LangP=6 wLevel=1
  c define: RT_USING_LIBC, __STDC_LIMIT_MACROS, RT_USING_ARMLIBC, __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND
  c misc: @via/rasc_armclang.via
  c include: ..\..\..\components\drivers\include;ra_cfg\fsp_cfg;..\..\..\components\libc\compilers\common\extension\fcntl\octal;.;..\libraries\HAL_Drivers;..\..\..\include;..\..\..\components\finsh;..\..\..\components\libc\posix\io\poll;..\..\..\components\drivers\include;board\ports;board;..\..\..\components\drivers\include;..\..\..\components\libc\posix\ipc;ra\fsp\inc\api;..\..\..\components\net\utest;..\..\..\components\libc\compilers\common\extension;ra\fsp\inc\instances;..\..\..\components\drivers\include;ra\fsp\inc;ra_gen;..\..\..\components\libc\posix\io\epoll;..\..\..\libcpu\arm\cortex-m23;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\libcpu\arm\common;ra\arm\CMSIS_6\CMSIS\Core\Include;..\..\..\components\libc\posix\io\eventfd;..\..\..\components\libc\compilers\common\include;..\..\..\components\drivers\smp_call;ra_cfg\fsp_cfg\bsp;..\libraries\HAL_Drivers\drivers\config;script\bsp_link\keil;..\..\..\components\drivers\phy;..\libraries\HAL_Drivers\drivers
  asm misc: --via=via/rasc_armasm.via
  scatter file: .\script\fsp.scat
  group Applications
    src/: hal_entry.c
  group CPU
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m23/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/pin/: dev_pin.c
    ../../../components/drivers/serial/: dev_serial_v2.c
  group Drivers
    ../libraries/HAL_Drivers/drivers/: drv_gpio.c drv_usart_v2.c
    ../libraries/HAL_Drivers/: drv_common.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group Libc
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
  group ra
    ra/fsp/src/bsp/mcu/all/: bsp_clocks.c bsp_common.c bsp_delay.c bsp_group_irq.c bsp_guard.c bsp_io.c bsp_ipc.c bsp_irq.c bsp_macl.c bsp_register_protection.c bsp_sbrk.c bsp_sdram.c bsp_security.c
    ra/fsp/src/bsp/mcu/ra2e2/: bsp_linker.c
    ra/fsp/src/bsp/cmsis/Device/RENESAS/Source/: system.c startup.c
    ra/fsp/src/r_ioport/: r_ioport.c
    ra/fsp/src/r_sci_uart/: r_sci_uart.c
  group ra_gen
    ra_gen/: common_data.c hal_data.c main.c pin_data.c vector_data.c
software components: Flex Software:RA Configuration 1.0.0
