# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L552ZETxQ STMicroelectronics
  pack: Keil.STM32L5xx_DFP.1.3.0
  cpu: IRAM(0x20000000,0x00040000) IRAM2(0x30000000,0x00040000) IROM(0x08000000,0x00080000) IROM2(0x0C000000,0x00080000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3
  c define: STM32L552xx, USE_HAL_DRIVER, __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND
  c include: .;applications;..\..\..\libcpu\arm\common;..\..\..\libcpu\arm\cortex-m33;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;board;board\CubeMX_Config\Inc;..\libraries\HAL_Drivers;..\libraries\HAL_Drivers\config;..\..\..\components\finsh;.;..\..\..\include;..\..\..\components\libc\compilers\common;..\..\..\components\libc\compilers\common\nogcc;..\libraries\STM32L5xx_HAL\STM32L5xx_HAL_Driver\Inc;..\libraries\STM32L5xx_HAL\CMSIS\Device\ST\STM32L5xx\Include;..\libraries\STM32L5xx_HAL\CMSIS\Include;..\..\..\components\libc\posix\io\poll;..\..\..\examples\utest\testcases\kernel
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group CPU
    ../../../libcpu/arm/common/: showmem.c div0.c backtrace.c
    ../../../libcpu/arm/cortex-m33/: trustzone.c syscall_rvds.S cpuport.c context_rvds.S
  group DeviceDrivers
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/src/: workqueue.c waitqueue.c ringblk_buf.c ringbuffer.c dataqueue.c completion.c pipe.c
  group Drivers
    ../libraries/STM32L5xx_HAL/CMSIS/Device/ST/STM32L5xx/Source/Templates/arm/: startup_stm32l552xx.s
    board/CubeMX_Config/Src/: stm32l5xx_hal_msp.c
    board/: board.c
    ../libraries/HAL_Drivers/: drv_gpio.c drv_usart.c drv_common.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c cmd.c
  group Kernel
    ../../../src/: kservice.c scheduler.c mempool.c thread.c components.c mem.c object.c clock.c idle.c timer.c device.c irq.c ipc.c
  group libc
    ../../../components/libc/compilers/common/: time.c
  group Libraries
    ../libraries/STM32L5xx_HAL/STM32L5xx_HAL_Driver/Src/: stm32l5xx_hal_pwr.c stm32l5xx_hal_dma_ex.c stm32l5xx_hal_gpio.c stm32l5xx_hal_rcc_ex.c stm32l5xx_hal_usart.c stm32l5xx_hal_uart_ex.c stm32l5xx_hal_pwr_ex.c stm32l5xx_hal_cryp.c stm32l5xx_hal_usart_ex.c stm32l5xx_hal_exti.c stm32l5xx_hal_cortex.c stm32l5xx_hal.c stm32l5xx_hal_rcc.c stm32l5xx_hal_dma.c stm32l5xx_hal_uart.c stm32l5xx_hal_comp.c stm32l5xx_hal_rng.c stm32l5xx_hal_crc.c stm32l5xx_hal_crc_ex.c stm32l5xx_hal_cryp_ex.c
    ../libraries/STM32L5xx_HAL/CMSIS/Device/ST/STM32L5xx/Source/Templates/: system_stm32l5xx.c
