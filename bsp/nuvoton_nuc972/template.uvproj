# Keil uVision project template.uvproj, settings and files
target rtthread (ARM-ADS)
  device: AT91SAM9260 Atmel
  cpu: IRAM(0x200000-0x200FFF) IRAM2(0x300000-0x300FFF) IROM(0x100000-0x107FFF) CLOCK(18432000) CPUTYPE(ARM926EJ-S)
  output: nuc972-rthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 uC99=1 wLevel=2
  c define: RT_USING_ARM_LIBC
  c include: Applications;.;components\emWin\emWin_Config;components\emWin\emWin_header;components\emWin\emWin_Demo;Drivers;.;E;:;..\..\..;e;m;b;S;t;u;d;i;o;..\..\..;w;o;r;k;s;p;a;c;e;..\..\..;N;U;C;9;7;2;_;R;T;-;T;h;r;e;a;d;..\..\..;P;l;a;t;f;o;r;m;rt-thread\include;rt-thread\libcpu\arm\arm926;rt-thread\libcpu\arm\common;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\spi;rt-thread\components\drivers\include;rt-thread\components\drivers\spi\sfud\inc;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\finsh;rt-thread\components\libc\compilers\armlibc
  asm include: .\platform
  memory RVCT1: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0x80000 size 0x800000
  scatter file: .\nuc970_ram.sct
  link misc: --keep *.o(.rti_fn.*)   --keep *.o(FSymTab) --keep *.o(VSymTab)
  group Applications
    Applications/: main.c
