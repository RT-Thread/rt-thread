# Keil uVision project lib_chip_5410x_m0.uvprojx, settings and files
target lib_chip_5410x_m0 (ARM-ADS)
  device: LPC54102:M0plus NXP
  pack: Keil.LPC54000_DFP.0.0.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x02000000,0x10000) IRAM2(0x02010000,0x08000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: lib_chip_5410x_m0 (library)
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: CORE_M0PLUS
  c include: .\config;..\chip_5410x;..\chip_common;..\..\..\CMSIS\CMSIS\Include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x2000000 size 0x10000
  memory RVCT10: RAM 0x2010000 size 0x8000
  group csp
    ../chip_common/: ring_buffer.c fpu_init.c iap.c rtc_ut.c
    ./: chip_5410x.c clock_5410x.c crc_5410x.c gpio_5410x.c iocon_5410x.c pinint_5410x.c sct_5410x.c sct_pwm_5410x.c syscon_5410x.c sysinit_5410x.c timer_5410x.c utick_5410x.c wwdt_5410x.c rtc_5410x.c gpiogroup_5410x.c stopwatch_5410x.c ritimer_5410x.c romapi_adc.c romapi_dma.c romapi_i2cm.c romapi_i2cmon.c romapi_i2cs.c romapi_spim.c romapi_spis.c romapi_uart.c pll_5410x.c hw_adc.c hw_dmaaltd.c hw_dmaaltd_rom_api.c hw_i2cmd.c hw_i2cmd_rom_api.c hw_i2cmond.c hw_i2cmond_rom_api.c hw_i2csd.c hw_i2csd_rom_api.c hw_spimd_rom_api.c hw_spisd.c hw_spisd_rom_api.c hw_spimd.c hw_uart.c fifo_5410x.c
  group lib
    ./power_lib/keil/: lib_power_m0.lib
