# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: TAE32G5800 Tai-Action
  pack: Tai-Action.TAE32G58xx_DFP.1.3.0
  cpu: IRAM(0x20000000,0x10000) IRAM2(0x20010000,0x10000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rt-thread +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: RT_USING_LIBC, __RTTHREAD__, __STDC_LIMIT_MACROS, TAE32G5800, RT_USING_ARMLIBC, __CLK_TCK=RT_TICK_PER_SECOND, USE_STDPERIPH_DRIVER
  c include: ..\libraries\TAE32G58xx_Firmware_Library\CMSIS\Include;..\..\..\components\libc\posix\io\epoll;.;..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\libraries\tae32_drivers\drv_flash;..\..\..\components\libc\posix\ipc;..\..\..\components\drivers\include;..\..\..\libcpu\arm\common;..\..\..\components\libc\posix\io\poll;..\..\..\components\drivers\include;..\..\..\components\drivers\smp_call;..\libraries\TAE32G58xx_Firmware_Library\TAE32G58xx_Device\Inc;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\include;..\..\..\components\drivers\phy;..\..\..\libcpu\arm\cortex-m4;..\libraries\tae32_drivers\config;..\libraries\TAE32G58xx_Firmware_Library\TAE32G58xx_Driver\Inc;..\..\..\components\drivers\include;board;board\ports;..\..\..\components\drivers\include;..\..\..\components\libc\posix\io\eventfd;..\..\..\components\net\utest;..\libraries\tae32_drivers;..\..\..\components\libc\compilers\common\include;..\..\..\components\finsh;..\..\..\components\libc\compilers\common\extension;..\..\..\components\fal\inc;applications;..\..\..\components\drivers\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x20010000 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../components/drivers/can/: dev_can.c
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/pin/: dev_pin.c
    ../../../components/drivers/serial/: dev_serial_v2.c
    ../../../components/drivers/watchdog/: dev_watchdog.c
  group Drivers
    ../libraries/TAE32G58xx_Firmware_Library/TAE32G58xx_Device/Src/: startup_tae32g58xx.c
    board/: board.c tae32g58xx_ll_msp.c
    ../libraries/tae32_drivers/: drv_can.c drv_gpio.c drv_uart_v2.c drv_wdt.c
    ../libraries/tae32_drivers/drv_flash/: drv_flash_g58xx.c
  group Fal
    ../../../components/fal/src/: fal_rtt.c fal_partition.c fal_flash.c fal.c
  group Finsh
    ../../../components/finsh/: shell.c cmd.c msh_parse.c msh.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    ../../../src/klibc/: rt_vsscanf.c kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c
  group libcpu
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group Libraries
    ../libraries/TAE32G58xx_Firmware_Library/TAE32G58xx_Device/Src/: system_tae32g58xx.c
    ../libraries/TAE32G58xx_Firmware_Library/TAE32G58xx_Driver/Src/: tae32g58xx_ll_eflash.c tae32g58xx_ll.c tae32g58xx_ll_gpio.c tae32g58xx_ll_uart.c tae32g58xx_ll_can.c tae32g58xx_ll_sysctrl.c tae32g58xx_ll_dma.c tae32g58xx_ll_cortex.c tae32g58xx_ll_rcu.c tae32g58xx_ll_iwdg.c
