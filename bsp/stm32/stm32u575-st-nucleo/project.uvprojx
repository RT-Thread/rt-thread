# Keil uVision project project.uvprojx, settings and files
target rtthread (6140000::V6.14::ARMCLANG)
  device: STM32U575ZITx STMicroelectronics
  pack: Keil.STM32U5xx_DFP.1.1.0
  cpu: IROM(0x08000000-0x81FFFFF) IRAM(0x20000000-0x200BFFFF) CLOCK(8000000) FPU3(SFPU) CPUTYPE("Cortex-M33") ELITTLE TZ
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER, STM32U575xx, __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND
  c include: .;applications;..\..\..\libcpu\arm\common;..\..\..\libcpu\arm\cortex-m33;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;board;board\CubeMX_Config\Inc;..\libraries\HAL_Drivers;..\libraries\HAL_Drivers\config;..\..\..\components\finsh;.;..\..\..\include;..\..\..\components\libc\compilers\common;..\..\..\components\libc\compilers\common\nogcc;..\libraries\STM32U5xx_HAL\STM32U5xx_HAL_Driver\Inc;..\libraries\STM32U5xx_HAL\CMSIS\Device\ST\STM32U5xx\Include;..\libraries\STM32U5xx_HAL\CMSIS\Include;..\..\..\components\libc\posix\io\poll;..\..\..\examples\utest\testcases\kernel
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0xc0000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group CPU
    ../../../libcpu/arm/common/: showmem.c backtrace.c div0.c
    ../../../libcpu/arm/cortex-m33/: context_rvds.S cpuport.c syscall_rvds.S trustzone.c
  group DeviceDrivers
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/src/: waitqueue.c dataqueue.c ringbuffer.c workqueue.c ringblk_buf.c pipe.c completion.c
  group Drivers
    board/CubeMX_Config/Src/: stm32u5xx_hal_msp.c
    ../libraries/STM32U5xx_HAL/CMSIS/Device/ST/STM32U5xx/Source/Templates/arm/: startup_stm32u575xx.s
    board/: board.c
    ../libraries/HAL_Drivers/: drv_gpio.c drv_usart.c drv_common.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c cmd.c
  group Kernel
    ../../../src/: ipc.c kservice.c object.c irq.c thread.c mempool.c device.c idle.c mem.c components.c timer.c scheduler.c clock.c
  group libc
    ../../../components/libc/compilers/common/: time.c
  group Libraries
    ../libraries/STM32U5xx_HAL/STM32U5xx_HAL_Driver/Src/: stm32u5xx_hal_uart.c stm32u5xx_hal.c stm32u5xx_hal_crc.c stm32u5xx_hal_icache.c stm32u5xx_hal_uart_ex.c stm32u5xx_hal_dma.c stm32u5xx_hal_usart.c stm32u5xx_hal_pwr.c stm32u5xx_hal_rcc.c stm32u5xx_hal_gpio.c stm32u5xx_hal_rng.c stm32u5xx_hal_cortex.c stm32u5xx_hal_cryp.c stm32u5xx_hal_crc_ex.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_usart_ex.c stm32u5xx_hal_cryp_ex.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_comp.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal_exti.c
    ../libraries/STM32U5xx_HAL/CMSIS/Device/ST/STM32U5xx/Source/Templates/: system_stm32u5xx.c
