# Keil uVision project project.uvprojx, settings and files
target rtthread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MIMXRT1061CVL5A NXP
  pack: NXP.MIMXRT1061_DFP.16.0.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x00000000,0x020000) IROM(0x00200000,0x020000) XRAM(0x20280000,0x040000) XRAM2(0x20200000,0x080000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: __STDC_LIMIT_MACROS, RT_USING_ARMLIBC, SKIP_SYSCLK_INIT, RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND, CPU_MIMXRT1061CVL5A, __RTTHREAD__, FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1, XIP_EXTERNAL_FLASH=1, EVK_MCIMXRM
  c misc: --library_interface=armcc --library_type=standardlib --diag_suppress=66,1296,186
  c include: applications;..\..\..\components\libc\compilers\common\extension;..\..\..\components\libc\compilers\common\include;..\..\..\libcpu\arm\cortex-m7;..\..\..\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;board\ports;..\..\..\components\drivers\include;..\libraries\MIMXRT1061\MIMXRT1061;..\..\..\components\libc\posix\ipc;..\libraries\MIMXRT1061\CMSIS\Include;..\..\..\components\libc\posix\io\eventfd;board\MCUX_Config;board;..\libraries\drivers;..\libraries\MIMXRT1061\MIMXRT1061\drivers;..\..\..\components\drivers\include;..\..\..\libcpu\arm\common;..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\components\libc\posix\io\poll;..\..\..\components\libc\posix\io\epoll;.;..\..\..\components\finsh
  memory RVCT4: ROM 0x200000 size 0x20000
  memory RVCT6: ROM 0x20280000 size 0x40000
  memory RVCT7: ROM 0x20200000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group CPU
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m7/: context_rvds.S cpu_cache.c cpuport.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/serial/: serial.c
  group Drivers
    board/MCUX_Config/: clock_config.c pin_mux.c
    board/: board.c
    ../libraries/drivers/: drv_common.c drv_gpio.c drv_uart.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../../src/: clock.c components.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler_up.c thread.c timer.c
  group Libraries
    ../libraries/MIMXRT1061/MIMXRT1061/drivers/: fsl_os_abstraction_rtthread.c fsl_xbara.c fsl_clock.c fsl_xbarb.c fsl_cache.c fsl_gpio.c fsl_lpuart.c generic_list.c fsl_common.c
    ../libraries/MIMXRT1061/MIMXRT1061/: system_MIMXRT1061.c
    ../libraries/MIMXRT1061/MIMXRT1061/arm/: startup_MIMXRT1061.s
