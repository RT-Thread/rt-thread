# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MM32F3277G8P MindMotion
  pack: MindMotion.MM32F3270_DFP.1.0.5
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rt-thread +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: __CLK_TCK=RT_TICK_PER_SECOND, __RTTHREAD__, __STDC_LIMIT_MACROS, RT_USING_LIBC, MM32F3277G, RT_USING_ARMLIBC
  c include: ..\..\..\components\net\utest;.;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\dfs\dfs_v1\include;..\..\..\components\drivers\include;..\..\..\components\libc\posix\io\poll;packages\mm32f3270x-hal-driver-latest\Inc;..\libraries\HAL_Drivers\drivers;..\libraries\HAL_Drivers;..\..\..\components\finsh;..\..\..\components\dfs\dfs_v1\filesystems\devfs;..\..\..\components\drivers\phy;packages\mm32f3270x-cmsis-latest\CMSIS\Include;..\..\..\components\drivers\include;..\..\..\components\libc\posix\io\epoll;..\..\..\components\libc\compilers\common\extension\fcntl\octal;board\ports;packages\mm32f3270x-cmsis-latest\CMSIS\Device\MM32\MM32F3277\Include;applications;..\..\..\components\drivers\include;..\..\..\components\libc\posix\io\eventfd;packages\mm32f3270x-cmsis-latest\CMSIS\Include;..\libraries\HAL_Drivers\drivers\config;..\..\..\components\drivers\include;..\..\..\components\libc\compilers\common\include;..\..\..\include;packages\mm32f3270x-cmsis-latest\CMSIS\Device\MM32\MM32F3277\Include;..\..\..\components\libc\compilers\common\extension;..\..\..\components\drivers\smp_call;..\..\..\libcpu\arm\common;..\..\..\libcpu\arm\cortex-m3;board;..\..\..\components\libc\posix\ipc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group CMSIS
    packages/mm32f3270x-cmsis-latest/CMSIS/Device/MM32/MM32F3277/Source/Templates/: system_mm32f3277g.c
    packages/mm32f3270x-cmsis-latest/CMSIS/Device/MM32/MM32F3277/Source/Templates/arm/: startup_mm32f3270.s
  group CPU
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m3/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/pin/: dev_pin.c
    ../../../components/drivers/serial/: dev_serial.c
  group Drivers
    board/: board.c mm32f3277g8p_msp.c
    board/ports/: user_key.c
    ../libraries/HAL_Drivers/drivers/: drv_gpio.c drv_uart.c
    ../libraries/HAL_Drivers/: drv_common.c
  group Filesystem
    ../../../components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    ../../../components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c msh_file.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group Libc
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
  group Libraries
    packages/mm32f3270x-hal-driver-latest/Src/: hal_adc.c hal_comp.c hal_dac.c hal_dma.c hal_exti.c hal_fsmc.c hal_gpio.c hal_i2c.c hal_iwdg.c hal_rcc.c hal_rtc.c hal_sdio.c hal_spi.c hal_syscfg.c hal_tim_16b.c hal_tim_32b.c hal_tim_adv.c hal_tim_basic.c hal_uart.c hal_usb.c hal_wwdg.c
