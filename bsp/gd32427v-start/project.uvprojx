# Keil uVision project project.uvprojx, settings and files
target rt-thread_gd32f4xx (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F427VK GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0300000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rtthread-gd32f4xx
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: __STDC_LIMIT_MACROS, RT_USING_ARMLIBC, GD32F427, USE_STDPERIPH_DRIVER, RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND, __RTTHREAD__
  c include: ..\..\components\libc\compilers\common\extension;.;Libraries\CMSIS;applications;Libraries\GD32F4xx_standard_peripheral\Include;Libraries\CMSIS\GD\GD32F4xx\Include;board;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\libc\posix\ipc;..\..\components\drivers\include;..\..\include;..\..\components\libc\compilers\common\include;..\..\components\finsh;..\..\libcpu\arm\common;..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\components\libc\posix\io\stdio;..\..\components\libc\posix\io\poll;..\..\libcpu\arm\cortex-m4
  memory RVCT4: ROM 0x8000000 size 0x300000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Applications
    applications/: main.c
  group Compiler
    ../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../components/libc/compilers/common/: cctype.c cstdio.c cstdlib.c cstring.c ctime.c cwchar.c
  group CPU
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../components/drivers/misc/: pin.c
    ../../components/drivers/serial/: serial.c
  group Drivers
    board/: drv_gpio.c drv_usart.c board.c
  group Finsh
    ../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group Libraries
    Libraries/GD32F4xx_standard_peripheral/Source/: gd32f4xx_can.c gd32f4xx_pmu.c gd32f4xx_i2c.c gd32f4xx_rtc.c gd32f4xx_enet.c gd32f4xx_dma.c gd32f4xx_tli.c gd32f4xx_gpio.c gd32f4xx_trng.c gd32f4xx_exmc.c gd32f4xx_wwdgt.c gd32f4xx_rcu.c gd32f4xx_misc.c gd32f4xx_adc.c gd32f4xx_ctc.c gd32f4xx_syscfg.c gd32f4xx_ipa.c gd32f4xx_crc.c gd32f4xx_fwdgt.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_timer.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_spi.c gd32f4xx_usart.c gd32f4xx_sdio.c gd32f4xx_iref.c gd32f4xx_dac.c
    Libraries/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f407_427.s
    Libraries/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
software components: CMSIS:CORE 5.6.0
