# Keil uVision project project.uvproj, settings and files
target rtthread (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: RT_USING_ARM_LIBC, __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND
  c include: applications;.;..\..\libcpu\arm\common;..\..\libcpu\arm\cortex-m4;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\drivers\include;drivers;..\..\components\finsh;.;..\..\include;..\..\components\libc\compilers\armlibc;..\..\components\libc\compilers\common;..\..\components\libc\compilers\common\nogcc;Libraries\CMSIS\CoreSupport;Libraries\CMSIS\DeviceSupport;Libraries\SWM320_StdPeriph_Driver;..\..\examples\utest\testcases\kernel
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\drivers\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group CPU
    ../../libcpu/arm/common/: div0.c backtrace.c showmem.c
    ../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../components/drivers/misc/: pin.c
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/src/: dataqueue.c waitqueue.c ringblk_buf.c ringbuffer.c workqueue.c completion.c pipe.c
  group Drivers
    drivers/: drv_gpio.c drv_uart.c board.c
  group Finsh
    ../../components/finsh/: shell.c msh.c cmd.c
  group Kernel
    ../../src/: timer.c object.c components.c clock.c irq.c scheduler.c thread.c kservice.c idle.c device.c memheap.c mempool.c ipc.c
  group libc
    ../../components/libc/compilers/armlibc/: libc.c syscalls.c mem_std.c
    ../../components/libc/compilers/common/: stdlib.c time.c
  group Libraries
    Libraries/SWM320_StdPeriph_Driver/: SWM320_wdt.c SWM320_rtc.c SWM320_flash.c SWM320_crc.c SWM320_i2c.c SWM320_gpio.c SWM320_sdio.c SWM320_sdram.c SWM320_can.c SWM320_pwm.c SWM320_adc.c SWM320_norflash.c SWM320_exti.c SWM320_timr.c SWM320_dma.c SWM320_uart.c SWM320_sram.c SWM320_lcd.c SWM320_spi.c SWM320_port.c
    Libraries/CMSIS/DeviceSupport/: system_SWM320.c
    Libraries/CMSIS/DeviceSupport/startup/arm/: startup_SWM320.s
