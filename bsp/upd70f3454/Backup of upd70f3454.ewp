# IAR project Backup of upd70f3454.ewp, settings and files
configuration Debug (V850, debug)
  General.GMemoryModel: 0
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl85-tnn.h
  General.GHeapSize: 4096
  General.GDeviceSelect: 70F3746 V850ES- uPD70F3746
  ICCV850.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCV850.CCOptLevel: 1
  ICCV850.CCOptStrategy: 0
  AV850.ADefines: CODE_MODEL_NORMAL; DATA_MODEL_TINY
  AV850.OAStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk85.xcl
  XLINK.XlinkStackSize: 1
configuration Release (V850)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICCV850.CCDefines: NDEBUG
  ICCV850.CCOptLevel: 3
  ICCV850.CCOptStrategy: 1
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: 
    applilet3_src/: CG_main.c CG_systeminit.c CG_option.s85 CG_system.c CG_system_user.c CG_port.c CG_port_user.c CG_serial.c CG_serial_user.c CG_timer.c CG_timer_user.c
