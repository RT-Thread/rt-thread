# Keil uVision project project_ns.uvprojx, settings and files
target rtthread-lpc55s6x (6120000::V6.12::.\ARMCLANG)
  device: LPC55S69JBD100:cm33_core0 NXP
  pack: NXP.LPC55S69_DFP.12.0.0
  cpu: IRAM(0x20000000,0x044000) IRAM2(0x04000000,0x8000) IROM(0x00000000,0x098000) XRAM(0x40100000,0x4000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: rtthread-lpc55s6x
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=3
  c define: CPU_LPC55S69JBD100_cm33_core0, RT_USING_ARM_LIBC, RT_USING_TFM
  c misc: --target=arm-arm-none-eabi
  c include: .;..\..\..\include;applications;board;board\MCUX_Config\board;..\Libraries\drivers;..\Libraries\drivers\config;..\..\..\libcpu\arm\common;..\..\..\libcpu\arm\cortex-m4;..\..\..\components\dfs\include;..\..\..\components\dfs\filesystems\devfs;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\spi;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\finsh;..\..\..\components\libc\compilers\armlibc;..\..\..\components\libc\compilers\common;..\Libraries\LPC55S6X\CMSIS\Include;..\Libraries\LPC55S6X\components\codec;..\Libraries\LPC55S6X\LPC55S6X;..\Libraries\LPC55S6X\LPC55S6X\drivers;..\Libraries\LPC55S6X\middleware\sdmmc\inc;..\Libraries\LPC55S6X\middleware\sdmmc\port;.\packages\trusted-firmware-m-v1.0-beta\interface\include
  memory RVCT4: ROM 0x0 size 0x98000
  memory RVCT6: RAM 0x40100000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x44000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: .\board\linker_scripts\LPC55S69_cm33_core0_flash_ns_mdk.scf
  group Kernel
    ../../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group Applications
    applications/: main.c
    ./applications/: tfm_ps.c
  group Drivers
    board/: board.c
    board/MCUX_Config/board/: clock_config.c pin_mux.c
    ../Libraries/drivers/: drv_pin.c drv_led.c drv_key.c drv_uart.c drv_rtc.c drv_spi.c drv_sd.c drv_i2c.c drv_mma8562.c drv_adc.c drv_hwtimer.c drv_pwm.c
  group cpu
    ../../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
  group Filesystem
    ../../../components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c poll.c select.c
    ../../../components/dfs/filesystems/devfs/: devfs.c
  group DeviceDrivers
    ../../../components/drivers/hwtimer/: hwtimer.c
    ../../../components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    ../../../components/drivers/misc/: pin.c adc.c rt_drv_pwm.c
    ../../../components/drivers/rtc/: rtc.c
    ../../../components/drivers/sdio/: block_dev.c mmcsd_core.c sd.c sdio.c mmc.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/spi/: spi_core.c spi_dev.c
    ../../../components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
  group finsh
    ../../../components/finsh/: shell.c cmd.c msh.c msh_file.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_var.c finsh_vm.c finsh_token.c
  group libc
    ../../../components/libc/compilers/armlibc/: libc.c mem_std.c stdio.c stubs.c
    ../../../components/libc/compilers/common/: time.c
  group Libraries
    ../Libraries/LPC55S6X/LPC55S6X/: system_LPC55S69_cm33_core0.c
    ../Libraries/LPC55S6X/LPC55S6X/arm/: startup_LPC55S69_cm33_core0.s keil_lib_power_cm33_core0.lib
    ../Libraries/LPC55S6X/LPC55S6X/drivers/: fsl_anactrl.c fsl_casper.c fsl_clock.c fsl_cmp.c fsl_common.c fsl_crc.c fsl_ctimer.c fsl_flexcomm.c fsl_dma.c fsl_gint.c fsl_gpio.c fsl_hashcrypt.c fsl_i2c.c fsl_i2c_dma.c fsl_i2s.c fsl_i2s_dma.c fsl_iap.c fsl_inputmux.c fsl_lpadc.c fsl_mrt.c fsl_ostimer.c fsl_pint.c fsl_plu.c fsl_power.c fsl_powerquad_basic.c fsl_prince.c fsl_puf.c fsl_reset.c fsl_rng.c fsl_rtc.c fsl_sctimer.c fsl_sdif.c fsl_spi.c fsl_spi_dma.c fsl_sysctl.c fsl_usart.c fsl_usart_dma.c fsl_utick.c fsl_wwdt.c
    ../Libraries/LPC55S6X/middleware/sdmmc/src/: fsl_sd.c fsl_sdmmc_common.c
    ../Libraries/LPC55S6X/middleware/sdmmc/port/sdif/rt_thread/: fsl_sdmmc_event.c fsl_sdmmc_host.c
  group TFM
    ./packages/trusted-firmware-m-v1.0-beta/interface/src/: tfm_sst_api.c tfm_ns_lock_rt-thread.c
    ./packages/trusted-firmware-m-v1.0-beta/cmake_build/install/export/tfm/veneers/: s_veneers.o
