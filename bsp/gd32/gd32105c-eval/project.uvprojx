# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: GD32F105VC GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.1
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(10800000) ELITTLE
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=4 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER, GD32F10X_CL, __RTTHREAD__, RT_USING_ARM_LIBC, __CLK_TCK=RT_TICK_PER_SECOND
  c include: applications;.;..\..\..\components\libc\compilers\common;..\..\..\components\libc\compilers\common\extension;..\..\..\libcpu\arm\common;..\..\..\libcpu\arm\cortex-m3;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;board;..\libraries\gd32_drivers;..\..\..\components\finsh;.;..\..\..\include;..\libraries\GD32F10x_Firmware_Library\CMSIS\GD\GD32F10x\Include;..\libraries\GD32F10x_Firmware_Library\CMSIS;..\libraries\GD32F10x_Firmware_Library\GD32F10x_standard_peripheral\Include;..\..\..\components\libc\posix\io\poll;..\..\..\components\libc\posix\io\stdio;..\..\..\components\libc\posix\ipc;..\..\..\examples\utest\testcases\kernel
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Applications
    applications/: main.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: time.c stdlib.c
  group CPU
    ../../../libcpu/arm/common/: div0.c backtrace.c showmem.c
    ../../../libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
  group DeviceDrivers
    ../../../components/drivers/ipc/: workqueue.c ringblk_buf.c dataqueue.c completion.c pipe.c waitqueue.c ringbuffer.c
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/serial/: serial.c
  group Drivers
    ../libraries/GD32F10x_Firmware_Library/CMSIS/GD/GD32F10x/Source/ARM/: startup_gd32f10x_cl.s
    board/: board.c
    ../libraries/gd32_drivers/: drv_gpio.c drv_usart.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c cmd.c
  group Kernel
    ../../../src/: components.c clock.c kservice.c irq.c scheduler.c ipc.c object.c thread.c timer.c device.c mempool.c idle.c mem.c
  group Libraries
    ../libraries/GD32F10x_Firmware_Library/GD32F10x_standard_peripheral/Source/: gd32f10x_exti.c gd32f10x_gpio.c gd32f10x_misc.c gd32f10x_rcu.c gd32f10x_usart.c
    ../libraries/GD32F10x_Firmware_Library/CMSIS/GD/GD32F10x/Source/: system_gd32f10x.c
software components: CMSIS:CORE 5.4.0
