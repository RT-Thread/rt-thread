# Keil uVision project template.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32WLE5JCIx STMicroelectronics
  pack: Keil.STM32WLxx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20008000,0x00008000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20008000 size 0x8000
  scatter file: .\board\linker_scripts\link.sct
