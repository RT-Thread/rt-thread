# Keil uVision project project.uvproj, settings and files
target LPC43xx SPIFI (ARM-ADS)
  device: LPC4357 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x1A000000-0x1A07FFFF) IROM2(0x1B000000-0x1B07FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: rtthread_lpc43xx
  c flags: Optim=1 OneElfS=1
  c define: BOOT_PROCESSOR, CORE_M4, __STDC_LIMIT_MACROS, __RTTHREAD__, USE_SPIFI, RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND, RT_USING_ARMLIBC
  c include: ..\..\..\..\..\components\drivers\phy;..\..\..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\finsh;applications;..\libraries\Device\NXP\LPC43xx\Include;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\libc\compilers\common\include;..\..\..\..\..\components\libc\posix\io\poll;..\..\..\..\..\include;.;..\..\..\..\..\components\drivers\smp_call;..\..\..\..\..\libcpu\arm\cortex-m4;..\..\..\..\..\components\libc\compilers\common\extension;..\..\..\..\..\components\libc\posix\ipc;..\..\..\..\..\components\libc\posix\io\eventfd;..\..\..\..\..\components\drivers\include;..\..\..\..\..\libcpu\arm\common;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\libc\posix\io\epoll;..\drivers;..\libraries\CMSIS\Include;..\..\..\..\..\components\net\utest
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT1: ROM 0x14000000 size 0x400000
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: .\rtthread_lpc43xx.sct
  group Applications
    applications/: application.c board.c startup.c
  group CMSIS
    ../libraries/Device/NXP/LPC43xx/Source/Templates/: system_LPC43xx.c
    ../libraries/Device/NXP/LPC43xx/Source/Templates/ARM/: startup_LPC43xx.s
  group CPU
    ../../../../../libcpu/arm/common/: div0.c showmem.c
    ../../../../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../../../../components/drivers/core/: device.c
    ../../../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../../components/drivers/serial/: dev_serial.c
  group Drivers
    ../drivers/: drv_led.c drv_uart.c
  group Finsh
    ../../../../../components/finsh/: shell.c msh.c msh_parse.c
  group Kernel
    ../../../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group Libc
    ../../../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../../../src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
