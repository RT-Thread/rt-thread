# IAR project rt_thread_demo_frdmkl27z.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MKL27Z64xxx4 Freescale MKL27Z64xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG; CPU_MKL27Z64VLH4; TWR_K64F120M
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ../../../../bsp/freescale/platform/devices; ../../../../bsp/freescale/platform/devices/MKL27Z644/include; ../../../../bsp/freescale/platform/devices/MKL27Z644/startup; ../../../../bsp/freescale/boards/frdmkl27z; ../../../../bsp/freescale/common/sgtl5000; ../../../../bsp/freescale/common/phyksz8041; ../../../../bsp/freescale/platform/system/src/clock/MKL27Z644; ../../../../bsp/freescale/rt_app; ../../../../bsp/freescale/platform/drivers/inc; ../../../../bsp/freescale/platform/hal/inc; ../../../../bsp/freescale/rtos; ../../../../bsp/freescale/platform/osa/inc; ../../../../bsp/freescale/platform/CMSIS/Include; ../../../../bsp/freescale/platform/system/inc; ../../../../bsp/freescale/platform/utilities/inc; ../../../../bsp/freescale/platform/utilities/src; ../../../../components/drivers/include/drivers; ../../../../components/drivers/include; ../../../../bsp/freescale/driver_wrapper/inc; ../../../../components/finsh; ../../../../include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: DEBUG
  OBJCOPY.OOCOutputFile: appgeneric.srec
  ILINK.IlinkOutputFile: rt_thread_demo.out
  ILINK.IlinkConfigDefines: __ram_vector_table__=1
  ILINK.IlinkIcfFile: ../../../../bsp/freescale/platform/devices/MKL27Z644/linker/iar/MKL27Z64xxx4_flash.icf
  ILINK.IlinkAdditionalLibs: ../../../../lib/ksdk_platform_lib/KsdkPlatformLib/iar/debug/libksdk_platform.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MKL27Z64VLH4; TWR_K64F120M
  ICCARM.CCOptLevel: 3
  ILINK.IlinkAdditionalLibs: ../../../../lib/ksdk_platform_lib/KsdkPlatformLib/iar/release/libksdk_platform.a
  group startup
    ../../../../bsp/freescale/platform/devices/MKL27Z644/startup/iar/: startup_MKL27Z644.s
    ../../../../bsp/freescale/platform/devices/MKL27Z644/startup/: system_MKL27Z644.c system_MKL27Z644.c system_MKL27Z644.c system_MKL27Z644.c system_MKL27Z644.c system_MKL27Z644.c system_MKL27Z644.c system_MKL27Z644.c system_MKL27Z644.c system_MKL27Z644.c system_MKL27Z644.c system_MKL27Z644.c
    ../../../../bsp/freescale/platform/devices/: startup.c startup.h startup.c startup.h startup.c startup.h startup.c startup.h startup.c startup.h startup.c startup.h startup.c startup.h startup.c startup.h startup.c startup.h startup.c startup.h startup.c startup.h startup.c startup.h
  group context
    ../../../../libcpu/arm/cortex-m0/: context_iar.S
  group uart_wrapper
    ../../../../bsp/freescale/driver_wrapper/uart/: drv_uart.c fsl_uart_irq_rt.c
    ../../../../bsp/freescale/driver_wrapper/inc/: drv_uart.h
  group board
    ../../../../bsp/freescale/boards/frdmkl27z/: gpio_pins.c gpio_pins.h board.c board.h pin_mux.c pin_mux.h gpio_pins.c gpio_pins.h board.c board.h pin_mux.c pin_mux.h gpio_pins.c gpio_pins.h board.c board.h pin_mux.c pin_mux.h gpio_pins.c gpio_pins.h board.c board.h pin_mux.c pin_mux.h gpio_pins.c gpio_pins.h board.c board.h pin_mux.c pin_mux.h gpio_pins.c gpio_pins.h board.c board.h pin_mux.c pin_mux.h gpio_pins.c gpio_pins.h board.c board.h pin_mux.c pin_mux.h gpio_pins.c gpio_pins.h board.c board.h pin_mux.c pin_mux.h gpio_pins.c gpio_pins.h board.c board.h pin_mux.c pin_mux.h gpio_pins.c gpio_pins.h board.c board.h pin_mux.c pin_mux.h gpio_pins.c gpio_pins.h board.c board.h pin_mux.c pin_mux.h gpio_pins.c gpio_pins.h board.c board.h pin_mux.c pin_mux.h
  group utils
    ../../../../bsp/freescale/boards/frdmkl27z/: rtconfig.h
    ../../../../bsp/freescale/platform/utilities/src/: fsl_debug_console.c print_scan.c print_scan.h fsl_misc_utilities.c
    ../../../../bsp/freescale/platform/utilities/inc/: fsl_debug_console.h
  group general
    ../../../../components/drivers/src/: completion.c pipe.c portal.c ringbuffer.c workqueue.c dataqueue.c
  group finsh
    ../../../../components/finsh/: cmd.c finsh.h finsh_compiler.c finsh_error.c finsh_error.h finsh_heap.c finsh_heap.h finsh_init.c finsh_node.c finsh_node.h finsh_ops.c finsh_ops.h finsh_parser.c finsh_parser.h finsh_token.c finsh_token.h finsh_var.c finsh_var.h finsh_vm.c finsh_vm.h msh.c msh.h msh_cmd.c shell.c shell.h symbol.c
  group serial
    ../../../../components/drivers/serial/: serial.c
    ../../../../components/drivers/include/drivers/: serial.h
  group rt_core
    ../../../../src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c module.c object.c scheduler.c slab.c thread.c timer.c
  group app_src
    ../../../../bsp/freescale/rt_app/: application.c startup_app.c board_app.c board_app.h
  group cortex_m0
    ../../../../libcpu/arm/cortex-m0/: cpuport.c
  group arm
    ../../../../libcpu/arm/common/: backtrace.c div0.c showmem.c
