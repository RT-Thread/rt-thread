# Keil uVision project template.uvprojx, settings and files
target rtthread-lpc546xx (ARM-ADS)
  device: LPC54608J512ET180:M4 NXP
  pack: Keil.LPC54000_DFP.2.4.0
  cpu: IROM(0x00000000,0x00080000) IRAM(0x20000000,0x00028000) IRAM2(0x04000000,0x00008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rtthread-lpc546xx
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: CPU_LPC54608, CPU_LPC54608J512ET180=1
  c misc: --library_interface=armcc --library_type=standardlib --diag_suppress=66,1296,186
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  scatter file: .\LPC54608J512_flash.scf
