# IAR project project.ewp, settings and files
configuration rt-thread (ARM, debug)
  General.OGChipSelectEditMenu: LPC4088 NXP LPC4088
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; _DLIB_FILE_DESCRIPTOR; __RTTHREAD__; CORE_M4; __RT_IPC_SOURCE__; __RT_KERNEL_SOURCE__
  ICCARM.CCDiagSuppress: Pa050,Pa082
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\..\..\..\include; ..\..\..\..\components\drivers\include; ..\..\..\..\components\libc\compilers\common\extension; ..\..\..\..\components\libc\compilers\common\include; drivers; ..\..\..\..\components\dfs\dfs_v1\filesystems\devfs; ..\..\..\..\components\libc\compilers\common\extension\fcntl\octal; Libraries\Drivers\include; ..\..\..\..\libcpu\arm\cortex-m4; ..\..\..\..\libcpu\arm\common; .; ..\..\..\..\components\libc\posix\delay; applications; ..\..\..\..\components\dfs\dfs_v1\include; Libraries\Device\NXP\LPC407x_8x_177x_8x\Include; ..\..\..\..\components\finsh; ..\..\..\..\components\libc\posix\io\poll; ..\..\..\..\components\drivers\phy; ..\..\..\..\components\libc\posix\io\epoll; ..\..\..\..\components\dfs\dfs_v1\filesystems\elmfat; ..\..\..\..\components\drivers\smp_call; ..\..\..\..\components\libc\posix\ipc; Libraries\CMSIS\Include; ..\..\..\..\components\drivers\ktime\inc; ..\..\..\..\components\drivers\ktime; ..\..\..\..\components\libc\posix\io\eventfd
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../../rtthread.bin
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: drivers\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: main.c
  group Compiler
    ../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../../components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
  group DeviceDrivers
    ../../../../components/drivers/core/: device.c
    ../../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../components/drivers/pin/: dev_pin.c
    ../../../../components/drivers/serial/: dev_serial.c
  group Drivers
    drivers/: drv_uart.c board.c
  group Filesystem
    ../../../../components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    ../../../../components/dfs/dfs_v1/filesystems/elmfat/: dfs_elm.c ff.c ffunicode.c
    ../../../../components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    ../../../../components/finsh/: shell.c cmd.c msh.c msh_parse.c msh_file.c
  group Kernel
    ../../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    ../../../../src/klibc/: kstdio.c kstring.c rt_vsscanf.c rt_vsnprintf_tiny.c kerrno.c
  group ktime
    ../../../../components/drivers/ktime/src/: hrtimer.c boottime.c cputimer.c
  group libcpu
    ../../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../../libcpu/arm/cortex-m4/: context_iar.S cpuport.c
  group Libraries
    Libraries/Device/NXP/LPC407x_8x_177x_8x/Source/Templates/IAR/: startup_LPC407x_8x_177x_8x.s
    Libraries/Device/NXP/LPC407x_8x_177x_8x/Source/Templates/: system_LPC407x_8x_177x_8x.c
    Libraries/Drivers/source/: lpc_adc.c lpc_bod.c lpc_can.c lpc_clkpwr.c lpc_crc.c lpc_dac.c lpc_eeprom.c lpc_emc.c lpc_exti.c lpc_gpdma.c lpc_gpio.c lpc_i2c.c lpc_i2s.c lpc_iap.c lpc_lcd.c lpc_mcpwm.c lpc_nvic.c lpc_pinsel.c lpc_pwm.c lpc_qei.c lpc_rtc.c lpc_ssp.c lpc_systick.c lpc_timer.c lpc_uart.c lpc_wwdt.c
  group POSIX
    ../../../../components/libc/posix/delay/: delay.c
