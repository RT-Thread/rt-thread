# Keil uVision project project.uvproj, settings and files
target LPC43xx SPIFI (ARM-ADS)
  device: LPC4357 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x1A000000-0x1A07FFFF) IROM2(0x1B000000-0x1B07FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: rtthread_lpc43xx
  c flags: Optim=1 OneElfS=1
  c define: USE_SPIFI, BOOT_PROCESSOR, CORE_M4, __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND
  c include: applications;.;..\Libraries\Device\NXP\LPC43xx\Include;..\Libraries\CMSIS\Include;..\..\..\libcpu\arm\common;..\..\..\libcpu\arm\cortex-m4;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\drivers;..\..\..\components\finsh;.;..\..\..\include;..\..\..\components\libc\compilers\common;..\..\..\components\libc\compilers\common\nogcc;..\..\..\examples\utest\testcases\kernel;..\..\..\components\vbus;..\..\..\components\vbus\share_hdr
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT1: ROM 0x14000000 size 0x400000
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
  scatter file: .\rtthread_lpc43xx.sct
  group Applications
    applications/: startup.c vbus_drv.c board.c application.c
  group CMSIS
    ../Libraries/Device/NXP/LPC43xx/Source/Templates/ARM/: startup_LPC43xx.s
    ../Libraries/Device/NXP/LPC43xx/Source/Templates/: system_LPC43xx.c
  group CPU
    ../../../libcpu/arm/common/: backtrace.c showmem.c div0.c
    ../../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/src/: ringblk_buf.c waitqueue.c workqueue.c ringbuffer.c dataqueue.c pipe.c completion.c
  group Drivers
    ../drivers/: drv_led.c drv_uart.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c
  group Kernel
    ../../../src/: mem.c clock.c device.c scheduler.c timer.c object.c ipc.c irq.c mempool.c memheap.c thread.c components.c kservice.c idle.c
  group VBus
    ../../../components/vbus/: prio_queue.c vbus_chnx.c watermark_queue.c vbus.c
