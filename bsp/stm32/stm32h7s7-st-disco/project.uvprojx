# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H7S7L8Hx STMicroelectronics
  pack: Keil.STM32H7Rx-7Sx_DFP.0.0.3
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5
  c define: STM32H7S7xx, RT_USING_ARMLIBC, USE_HAL_DRIVER, RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND, __STDC_LIMIT_MACROS, __RTTHREAD__
  c include: ..\..\..\components\drivers\include;..\..\..\components\drivers\spi;..\..\..\include;..\..\..\components\drivers\include;..\libraries\HAL_Drivers\drivers;..\libraries\STM32H7RSxx_HAL\STM32H7RSxx_HAL_Driver\Inc;..\..\..\components\drivers\include;board\CubeMX_Config\Appli\Core\Inc;..\..\..\components\drivers\include;..\..\..\components\libc\posix\ipc;..\libraries\HAL_Drivers\CMSIS\Include;..\..\..\components\libc\compilers\common\extension;applications;..\..\..\components\finsh;..\..\..\components\libc\posix\io\eventfd;board\port;..\..\..\components\libc\compilers\common\include;..\..\..\components\drivers\include;..\..\..\libcpu\arm\cortex-m7;..\..\..\components\libc\posix\io\poll;..\..\..\libcpu\arm\common;..\..\..\components\drivers\touch;.;..\libraries\STM32H7RSxx_HAL\CMSIS\Device\ST\STM32H7RSxx\Include;..\..\..\components\drivers\include;..\..\..\components\libc\posix\io\epoll;..\..\..\components\drivers\include;..\libraries\HAL_Drivers;..\..\..\components\libc\compilers\common\extension\fcntl\octal;board;..\libraries\HAL_Drivers\drivers\config
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/i2c/: i2c-bit-ops.c i2c_core.c i2c_dev.c
    ../../../components/drivers/ipc/: completion.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/pin/: pin.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/spi/: spi_core.c spi_dev.c
    ../../../components/drivers/touch/: touch.c
  group Drivers
    ../libraries/STM32H7RSxx_HAL/CMSIS/Device/ST/STM32H7RSxx/Source/Templates/arm/: startup_stm32h7s7xx.s
    board/CubeMX_Config/Appli/Core/Src/: stm32h7rsxx_hal_msp.c
    board/: board.c
    ../libraries/HAL_Drivers/drivers/: drv_gpio.c drv_spi.c drv_usart.c
    ../libraries/HAL_Drivers/: drv_common.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../../src/: clock.c components.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
    ../../../src/klibc/: kstdio.c kstring.c
  group libcpu
    ../../../libcpu/arm/common/: div0.c showmem.c
    ../../../libcpu/arm/cortex-m7/: context_rvds.S cpu_cache.c cpuport.c
  group Libraries
    ../libraries/STM32H7RSxx_HAL/STM32H7RSxx_HAL_Driver/Src/: stm32h7rsxx_hal_cryp.c stm32h7rsxx_hal_cortex.c stm32h7rsxx_hal_dma_ex.c stm32h7rsxx_hal_gpio.c stm32h7rsxx_hal_rng.c stm32h7rsxx_hal_adc_ex.c stm32h7rsxx_hal_rcc.c stm32h7rsxx_hal_pwr.c stm32h7rsxx_hal_usart.c stm32h7rsxx_hal_dma.c stm32h7rsxx_hal_pwr_ex.c stm32h7rsxx_hal.c stm32h7rsxx_hal_flash.c stm32h7rsxx_hal_cec.c stm32h7rsxx_hal_sram.c stm32h7rsxx_hal_uart_ex.c stm32h7rsxx_hal_flash_ex.c stm32h7rsxx_hal_adc.c stm32h7rsxx_hal_xspi.c stm32h7rsxx_hal_uart.c stm32h7rsxx_hal_crc.c stm32h7rsxx_hal_rcc_ex.c stm32h7rsxx_hal_crc_ex.c stm32h7rsxx_hal_cryp_ex.c
    ../libraries/STM32H7RSxx_HAL/CMSIS/Device/ST/STM32H7RSxx/Source/Templates/: system_stm32h7rsxx.c
