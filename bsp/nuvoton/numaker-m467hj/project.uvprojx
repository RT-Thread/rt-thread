# Keil uVision project project.uvprojx, settings and files
target rtthread-m460 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: M467HJHAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.13
  cpu: IRAM(0x20000000,0x80000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: rtthread +hex
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 v6Lang=1 v6LangP=1
  c define: __STDC_LIMIT_MACROS, __CLK_TCK=RT_TICK_PER_SECOND, RT_USING_ARMLIBC, __RTTHREAD__, RT_USING_LIBC
  c misc: --c99 --diag_suppress=66,1296,186
  c include: ..\..\..\components\drivers\include;..\..\..\components\utilities\utest;..\..\..\components\dfs\dfs_v1\filesystems\elmfat;..\libraries\m460\rtt_port;..\libraries\nu_packages\NCT7717U;..\..\..\components\libc\posix\io\poll;..\..\..\include;board;..\..\..\components\net\lwip\lwip-2.1.2\src\include\netif;..\..\..\components\net\sal\include\socket\sys_socket;..\..\..\components\drivers\include;..\..\..\components\drivers\include;board\NuPinConfig;..\..\..\components\libc\compilers\common\extension;..\libraries\m460\USBHostLib\inc;..\..\..\components\legacy\usb\usbhost\core;..\..\..\components\drivers\audio;..\libraries\m460\Device\Nuvoton\m460\Include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\dfs\dfs_v1\include;..\..\..\components\net\lwip\port;..\..\..\components\libc\posix\io\epoll;..\..\..\components\net\sal\impl;..\..\..\components\finsh;..\..\..\libcpu\arm\common;..\libraries\nu_packages\AudioCodec;..\..\..\components\drivers\include;..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\components\drivers\include;..\..\..\components\net\sal\include\dfs_net;..\..\..\components\drivers\smp_call;..\..\..\components\legacy\usb\usbhost\include;..\..\..\components\net\sal\include\socket;..\..\..\libcpu\arm\cortex-m4;..\..\..\components\libc\posix\io\eventfd;..\..\..\components\drivers\spi;..\libraries\m460\StdDriver\inc;..\..\..\components\net\lwip\lwip-2.1.2\src\include;..\..\..\components\drivers\include;..\libraries\nu_packages\TPC;..\..\..\components\legacy;..\..\..\components\utilities\ulog;..\..\..\components\drivers\phy;..\..\..\components\drivers\include;applications;..\..\..\components\dfs\dfs_v1\filesystems\devfs;..\..\..\components\drivers\sdio\sdhci\include;..\..\..\components\legacy\usb\usbhost;..\..\..\components\legacy\usb\usbhost\class;..\..\..\components\drivers\include;..\..\..\components\legacy\dfs;..\..\..\components\drivers\include;..\libraries\m460\rtt_port\emac;..\..\..\components\drivers\hwcrypto;.;..\libraries\nu_packages\NuUtils\inc;..\..\..\components\legacy\usb\usbdevice;..\..\..\components\drivers\spi\sfud\inc;..\..\..\components\libc\compilers\common\include;..\..\..\components\net\sal\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\legacy\include;..\..\..\components\libc\posix\ipc;..\..\..\components\net\netdev\include;..\..\..\components\fal\inc;..\libraries\m460\CMSIS\Include
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x80000
  scatter file: .\linking_scripts\m460_flash.sct
  group Applications
    applications/: mnt.c main.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../components/drivers/audio/: dev_audio.c dev_audio_pipe.c
    ../../../components/drivers/can/: dev_can.c
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/hwcrypto/: hw_crc.c hw_hash.c hw_rng.c hw_symmetric.c hwcrypto.c
    ../../../components/drivers/hwtimer/: hwtimer.c
    ../../../components/drivers/i2c/: dev_i2c_bit_ops.c dev_i2c_core.c dev_i2c_dev.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/misc/: rt_drv_pwm.c rt_inputcapture.c
    ../../../components/drivers/pin/: dev_pin.c
    ../../../components/drivers/rtc/: dev_rtc.c
    ../../../components/drivers/sdio/: dev_block.c dev_mmc.c dev_mmcsd_core.c dev_sd.c dev_sdio.c
    ../../../components/drivers/sensor/v2/: sensor.c sensor_cmd.c
    ../../../components/drivers/serial/: dev_serial.c
    ../../../components/drivers/spi/: dev_qspi_core.c dev_spi.c dev_spi_core.c dev_spi_flash_sfud.c
    ../../../components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    ../../../components/drivers/watchdog/: dev_watchdog.c
  group Drivers
    ../libraries/m460/Device/Nuvoton/m460/Source/ARM/: startup_m460.s
    ../libraries/m460/Device/Nuvoton/m460/Source/: system_m460.c
    ../libraries/m460/rtt_port/: drv_bpwm.c drv_bpwm_capture.c drv_canfd.c drv_ccap.c drv_common.c drv_crc.c drv_crypto.c drv_dac.c drv_eadc.c drv_ebi.c drv_ecap.c drv_epwm.c drv_epwm_capture.c drv_eqei.c drv_fmc.c drv_gpio.c drv_hsotg.c drv_hsusbd.c drv_i2c.c drv_i2s.c drv_pdma.c drv_qspi.c drv_rtc.c drv_scuart.c drv_sdh.c drv_sdio.c drv_softi2c.c drv_spi.c drv_spii2s.c drv_timer.c drv_tpwm.c drv_trng.c drv_uart.c drv_ui2c.c drv_usbd.c drv_usbhost.c drv_uspi.c drv_uuart.c drv_wdt.c
    board/NuPinConfig/: nutool_pincfg.c
    board/: board_dev.c nutool_modclkcfg.c
    ../libraries/m460/rtt_port/emac/: drv_emac.c mii.c synopGMAC_Dev.c synopGMAC_network_interface.c synopGMAC_plat.c
  group Fal
    ../../../components/fal/src/: fal_partition.c fal_rtt.c fal_flash.c fal.c
    ../../../components/fal/samples/porting/: fal_flash_sfud_port.c
  group Filesystem
    ../../../components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    ../../../components/dfs/dfs_v1/filesystems/elmfat/: dfs_elm.c ff.c ffunicode.c
    ../../../components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    ../../../components/finsh/: msh.c shell.c msh_file.c msh_parse.c cmd.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c signal.c thread.c timer.c
  group klibc
    ../../../src/klibc/: kerrno.c kstring.c rt_vsscanf.c rt_vsnprintf_tiny.c kstdio.c
  group Legacy
    ../../../components/legacy/ipc/: workqueue_legacy.c
  group libcpu
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group Libraries
    ../libraries/m460/StdDriver/src/: nu_sdh.c nu_usci_uart.c nu_wdt.c nu_pdma.c nu_sc.c nu_ecap.c nu_clk.c nu_uart.c nu_dac.c nu_timer_pwm.c nu_ebi.c nu_usci_i2c.c nu_usci_spi.c nu_eadc.c nu_spi.c nu_hsusbd.c nu_fmc.c nu_wwdt.c nu_eqei.c nu_usbd.c nu_i2s.c nu_kpi.c nu_canfd.c nu_spim.c nu_crypto.c nu_qspi.c nu_crc.c nu_sys.c nu_keystore.c nu_scuart.c nu_rng.c nu_epwm.c nu_ccap.c nu_rtc.c nu_i2c.c nu_trng.c nu_bmc.c nu_gpio.c nu_timer.c nu_bpwm.c nu_hbi.c nu_acmp.c
  group lwIP
    ../../../components/net/lwip/lwip-2.1.2/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../components/net/lwip/lwip-2.1.2/src/apps/ping/: ping.c
    ../../../components/net/lwip/lwip-2.1.2/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../components/net/lwip/lwip-2.1.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../components/net/lwip/lwip-2.1.2/src/netif/: ethernet.c lowpan6.c
    ../../../components/net/lwip/port/: ethernetif.c sys_arch.c
  group m460_usbhostlib
    ../libraries/m460/USBHostLib/src/: mem_alloc.c ohci.c ehci_iso.c ehci.c usb_core.c
  group nu_pkgs_nau8822
    ../libraries/nu_packages/AudioCodec/: acodec_nau8822.c audio_test.c
  group nu_pkgs_nct7717u
    ../libraries/nu_packages/NCT7717U/: sensor_nct7717u.c
  group POSIX
    ../../../components/libc/posix/io/poll/: poll.c select.c
  group rt_usbd
    ../../../components/legacy/usb/usbdevice/core/: usbdevice.c usbdevice_core.c
    ../../../components/legacy/usb/usbdevice/class/: mstorage.c
  group rt_usbh
    ../../../components/legacy/usb/usbhost/core/: usbhost_core.c usbhost.c driver.c hub.c
    ../../../components/legacy/usb/usbhost/class/: mass.c udisk.c
  group SAL
    ../../../components/net/netdev/src/: netdev.c netdev_ipaddr.c
    ../../../components/net/sal/dfs_net/: dfs_net.c
    ../../../components/net/sal/impl/: af_inet_lwip.c
    ../../../components/net/sal/socket/: net_netdb.c net_sockets.c
    ../../../components/net/sal/src/: sal_socket.c
  group UTest
    ../../../components/utilities/utest/: utest.c TC_uassert.c
  group Utilities
    ../../../components/utilities/ulog/: ulog.c
    ../../../components/utilities/ulog/backend/: console_be.c
software components: CMSIS:CORE 5.4.0
