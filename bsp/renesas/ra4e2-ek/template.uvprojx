# Keil uVision project template.uvprojx, settings and files
target Target_1 (ARM-ADS)
  device: R7FA4E2B9 Renesas
  pack: Renesas.RA_DFP.6.0.0
  cpu: CPUTYPE("Cortex-M33") DSP TZ  FPU3(SFPU)  CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: v6Lang=3 v6LangP=6
  scatter file: .\script\fsp.scat
software components: Flex Software:RA Configuration 1.0.0
