# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ES32F3656LT Eastsoft
  pack: Eastsoft.ES32_DFP.7.2350
  cpu: IRAM(0x20000000,0x00018000) IROM(0x00000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: RT_USING_ARMLIBC, __RTTHREAD__, ES32F36xx, RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND, __STDC_LIMIT_MACROS
  c include: drivers\ES;..\..\..\components\finsh;..\..\..\components\libc\compilers\common\extension\fcntl\octal;.;..\..\..\components\drivers\phy;..\..\..\components\net\utest;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\libc\posix\io\eventfd;drivers;..\..\..\components\drivers\include;..\..\..\libcpu\arm\cortex-m3;..\..\..\components\drivers\smp_call;..\..\..\components\libc\posix\ipc;applications;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\libcpu\arm\common;..\es32f369x\libraries\CMSIS\Device\EastSoft\ES32F36xx\Include;..\es32f369x\libraries\ES32F36xx_ALD_StdPeriph_Driver\Include;..\..\..\include;..\..\..\components\libc\posix\io\poll;..\..\..\components\drivers\include;..\es32f369x\libraries\CMSIS\Include;..\..\..\components\libc\compilers\common\include;..\..\..\components\libc\compilers\common\extension;..\..\..\components\libc\posix\io\epoll
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Applications
    applications/: main.c
  group CPU
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m3/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/pin/: dev_pin.c
    ../../../components/drivers/serial/: dev_serial.c
  group Drivers
    drivers/: board.c
    ../es32f369x/drivers/: drv_gpio.c drv_uart.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c signal.c thread.c timer.c
  group Libc
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
  group Libraries
    ../es32f369x/libraries/ES32F36xx_ALD_StdPeriph_Driver/Source/: ald_acmp.c ald_adc.c ald_bkpc.c ald_calc.c ald_can.c ald_cmu.c ald_crc.c ald_crypt.c ald_dac.c ald_dma.c ald_ebi.c ald_flash.c ald_flash_ext.c ald_gpio.c ald_i2c.c ald_i2s.c ald_iap.c ald_nand.c ald_nor_lcd.c ald_pis.c ald_pmu.c ald_qspi.c ald_rmu.c ald_rtc.c ald_rtchw.c ald_spi.c ald_sram.c ald_timer.c ald_trng.c ald_tsense.c ald_uart.c ald_usb.c ald_wdt.c utils.c
    ../es32f369x/libraries/CMSIS/Device/EastSoft/ES32F36xx/Startup/keil/: startup_es32f36xx.s
