# Keil uVision project project.uvprojx, settings and files
target rt-thread (ARM-ADS)
  device: GD32F450IK GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x040000) IROM(0x08000000,0x0300000) CPUTYPE("Cortex-M4") FPU2 CLOCK(20000000) ELITTLE
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=4 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER, GD32F450, __RTTHREAD__, RT_USING_ARM_LIBC, __CLK_TCK=RT_TICK_PER_SECOND
  c include: applications;.;..\..\..\components\libc\compilers\common;..\..\..\components\libc\compilers\common\extension;..\..\..\libcpu\arm\common;..\..\..\libcpu\arm\cortex-m4;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;board;..\libraries\gd32_drivers;..\..\..\components\finsh;.;..\..\..\include;..\libraries\GD32F4xx_Firmware_Library\CMSIS\GD\GD32F4xx\Include;..\libraries\GD32F4xx_Firmware_Library\CMSIS;..\libraries\GD32F4xx_Firmware_Library\GD32F4xx_standard_peripheral\Include;..\..\..\components\libc\posix\io\poll;..\..\..\components\libc\posix\io\stdio;..\..\..\components\libc\posix\ipc;..\..\..\examples\utest\testcases\kernel
  memory RVCT4: ROM 0x8000000 size 0x300000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Applications
    applications/: main.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscalls.c syscall_mem.c
    ../../../components/libc/compilers/common/: stdlib.c time.c
  group CPU
    ../../../libcpu/arm/common/: showmem.c backtrace.c div0.c
    ../../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../../components/drivers/ipc/: ringbuffer.c pipe.c dataqueue.c waitqueue.c workqueue.c ringblk_buf.c completion.c
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/serial/: serial.c
  group Drivers
    ../libraries/GD32F4xx_Firmware_Library/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f4xx.s
    board/: board.c
    ../libraries/gd32_drivers/: drv_gpio.c drv_usart.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c cmd.c
  group Kernel
    ../../../src/: timer.c thread.c clock.c irq.c scheduler.c object.c kservice.c components.c device.c idle.c mempool.c ipc.c mem.c
  group Libraries
    ../libraries/GD32F4xx_Firmware_Library/GD32F4xx_standard_peripheral/Source/: gd32f4xx_syscfg.c gd32f4xx_exti.c gd32f4xx_gpio.c gd32f4xx_rcu.c gd32f4xx_misc.c gd32f4xx_usart.c
    ../libraries/GD32F4xx_Firmware_Library/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
software components: CMSIS:CORE 5.0.1
