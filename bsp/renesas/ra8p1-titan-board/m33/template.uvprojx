# Keil uVision project template.uvprojx, settings and files
target M33_Debug_CPU1 (6190000::V6.19::ARMCLANG)
  device: R7KA8P1KF:CPU1 Renesas
  pack: Renesas.RA_DFP.6.1.0
  cpu: CPUTYPE("Cortex-M33") DSP TZ FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: template +hex
  AfterMake: cmd /c ""$Prasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --gensmartbundle --compiler ARMv6 --devicefamily ra "$Pconfiguration.xml" "$L%L" 2> "$PObjects\rasc_stderr.out""
  c flags: v6Lang=3 v6LangP=6
  asm include: .
  scatter file: .\script\fsp.scat
  link misc: --entry=Reset_Handler --no_startup
target M33_Download_CPU0 (6190000::V6.19::ARMCLANG)
  device: R7KA8P1KF:CPU0 Renesas
  pack: Renesas.RA_DFP.6.1.0
  cpu: CPUTYPE("Cortex-M85") DSP TZ MVE(FP) FPU3(DFPU) PACBTI CLOCK(12000000) ELITTLE
  output: template
  AfterMake: as above
  c flags: v6Lang=3 v6LangP=6
  scatter file: .\script\fsp.scat
  link misc: --entry=Reset_Handler --no_startup
software components: Flex Software:RA Configuration 1.0.0
