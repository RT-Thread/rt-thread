# IAR project KsdkStdLib_K64F12.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK64FN1M0xxx12 Freescale MK64FN1M0xxx12
  ICCARM.CCDefines: DEBUG; CPU_MK64FN1M0VMD12
  ICCARM.CCDiagSuppress: Pa039,Pe068,Pe069,Pa082,Pe177,Pe186,Pe550,Pa050
  ICCARM.CCIncludePath2: ../../../../utilities/stdlib/include; ../../../../utilities/stdlib/stdio; ../../../../platform/utilities/src; ../../../../include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: DEBUG
  ILINK.IlinkOutputFile: psp_arm.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MK64FN1M0VMD12
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: libgeneric.out
  group std/include
    ../../../../utilities/stdlib/include/: strings.h std_prv.h stdio.h
  group std/stdio
    ../../../../utilities/stdlib/stdio/: buf_prv.c buf_prv.h err.c fclose.c fflush.c fopen.c fread.c fwrite.c get.c pos.c print.c put.c scan.c stdio.c std_prv.c
    ../../../../platform/utilities/src/: print_scan.c print_scan.h
  group std/strings
    ../../../../utilities/stdlib/strings/: strings.c
