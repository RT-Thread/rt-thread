# Keil uVision project project.uvprojx, settings and files
target rtthread (6160000::V6.16::ARMCLANG)
  device: MIMXRT1062DVL6A NXP
  pack: NXP.MIMXRT1062_DFP.14.0.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x00000000,0x020000) IROM(0x00200000,0x020000) XRAM(0x20280000,0x040000) XRAM2(0x20200000,0x080000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rtthread
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DATA_SECTION_IS_CACHEABLE=1, __STDC_LIMIT_MACROS, SKIP_SYSCLK_INIT, XIP_BOOT_HEADER_DCD_ENABLE=1, XIP_BOOT_HEADER_ENABLE=1, RT_USING_ARMLIBC, __FPU_PRESENT=1, __CLK_TCK=RT_TICK_PER_SECOND, EVK_MCIMXRM, CPU_MIMXRT1062DVL6A, RT_USING_LIBC, XIP_EXTERNAL_FLASH=1, __RTTHREAD__, FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1, FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1
  c misc: -fno-common -fdata-sections -ffreestanding -fno-builtin -mthumb
  c include: ..\..\..\..\..\components\drivers\include;.;..\..\..\..\..\components\libc\posix\io\eventfd;..\libraries\MIMXRT1060\MIMXRT1060;..\..\..\..\..\components\libc\posix\io\epoll;..\libraries\drivers;..\..\..\..\..\libcpu\arm\cortex-m7;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\finsh;board\MCUX_Config;..\..\..\..\..\components\libc\posix\io\poll;..\..\..\..\..\components\drivers\phy;..\..\..\..\..\components\libc\compilers\common\extension;..\..\..\..\..\components\drivers\smp_call;..\libraries\MIMXRT1060\MIMXRT1060\drivers;..\..\..\..\..\libcpu\arm\common;applications;..\..\..\..\..\include;xip;..\..\..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\..\..\components\libc\posix\ipc;board;..\..\..\..\..\components\libc\compilers\common\include;board\ports;..\..\..\..\..\components\drivers\include;..\libraries\MIMXRT1060\CMSIS\Include
  asm define: DEBUG, __STARTUP_INITIALIZE_NONCACHEDATA
  memory RVCT1: ROM 0x60000000 size 0x4000000
  memory RVCT4: ROM 0x200000 size 0x20000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: .\board\linker_scripts\link.sct
  link misc: --keep=*(.boot_hdr.ivt)--keep=*(.boot_hdr.boot_data)--keep=*(.boot_hdr.dcd_data)--keep=*(.boot_hdr.conf)--entry=Reset_Handler --predefine="-DXIP_BOOT_HEADER_ENABLE=1"
  group Applications
    applications/: main.c mnt.c
  group Compiler
    ../../../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../../../components/drivers/core/: device.c
    ../../../../../components/drivers/i2c/: dev_i2c_bit_ops.c dev_i2c_core.c dev_i2c_dev.c
    ../../../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../../components/drivers/phy/: phy.c
    ../../../../../components/drivers/pin/: dev_pin.c
    ../../../../../components/drivers/serial/: dev_serial.c
  group Drivers
    board/MCUX_Config/: clock_config.c dcd.c pin_mux.c
    board/: board.c
    ../libraries/drivers/: drv_common.c drv_gpio.c drv_uart.c
  group Finsh
    ../../../../../components/finsh/: msh.c msh_parse.c shell.c cmd.c
  group Kernel
    ../../../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    ../../../../../src/klibc/: rt_vsnprintf_tiny.c kstdio.c rt_vsscanf.c kerrno.c kstring.c
  group libcpu
    ../../../../../libcpu/arm/common/: div0.c showmem.c
    ../../../../../libcpu/arm/cortex-m7/: context_rvds.S cpu_cache.c cpuport.c
  group Libraries
    ../libraries/MIMXRT1060/MIMXRT1060/drivers/: fsl_lpuart.c fsl_gpio.c fsl_common_arm.c fsl_clock.c generic_list.c fsl_cache.c fsl_os_abstraction_rtthread.c fsl_xbara.c fsl_common.c fsl_xbarb.c
    ../libraries/MIMXRT1060/MIMXRT1060/arm/: startup_MIMXRT1062.s
    ../libraries/MIMXRT1060/MIMXRT1060/: system_MIMXRT1062.c
  group xip
    xip/: fsl_flexspi_nor_boot.c evkmimxrt1060_flexspi_nor_config.c
