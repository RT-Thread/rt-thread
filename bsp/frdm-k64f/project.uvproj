# Keil uVision project project.uvproj, settings and files
target RT-Thread (ARM-ADS)
  device: MK64FN1M0xxx12 Freescale Semiconductor
  cpu: IRAM(0x1FFF0000-0x1FFFFFFF) IRAM2(0x20000000-0x2002FFFF) IROM(0x0-0xFFFFF) CLOCK(12000000) CPUTYPE("Cortex-M4")  FPU2 ELITTLE
  output: rt-thread-k64f
  c flags: Optim=1
  c define: RT_USING_LIBC, __RTTHREAD__, __STDC_LIMIT_MACROS, CPU_MK64FN1M0VLL12, __CLK_TCK=RT_TICK_PER_SECOND, RT_USING_ARMLIBC
  c include: ..\..\include;device\MK64F12;..\..\components\drivers\include;..\..\components\libc\compilers\common\include;..\..\libcpu\arm\cortex-m4;device;..\..\components\libc\posix\io\eventfd;..\..\components\net\lwip\lwip-2.0.3\src\include\ipv4;applications;..\..\components\net\utest;..\..\components\drivers\include;..\..\components\net\lwip\lwip-2.0.3\src\include;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\net\lwip\lwip-2.0.3\src\include\netif;..\..\libcpu\arm\common;..\..\components\libc\posix\io\poll;..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\components\drivers\phy;..\..\components\libc\posix\ipc;..\..\components\drivers\smp_call;board;.;..\..\components\libc\posix\io\epoll;..\..\components\drivers\include;..\..\components\libc\compilers\common\extension;..\..\components\finsh;..\..\components\net\lwip\port;..\..\components\net\lwip\lwip-2.0.3\src\include\posix
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  group Applications
    applications/: application.c startup.c
  group CPU
    ../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../components/drivers/core/: device.c
    ../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../components/drivers/pin/: dev_pin.c
    ../../components/drivers/serial/: dev_serial.c
  group Drivers
    board/: board.c clock_config.c drv_emac.c drv_uart.c fsl_phy.c led.c
    device/MK64F12/: fsl_adc16.c fsl_clock.c fsl_cmp.c fsl_cmt.c fsl_common.c fsl_crc.c fsl_dac.c fsl_dmamux.c fsl_dspi.c fsl_dspi_edma.c fsl_edma.c fsl_enet.c fsl_ewm.c fsl_flash.c fsl_flexbus.c fsl_flexcan.c fsl_ftm.c fsl_gpio.c fsl_i2c.c fsl_i2c_edma.c fsl_llwu.c fsl_lptmr.c fsl_pdb.c fsl_pit.c fsl_pmc.c fsl_rcm.c fsl_rnga.c fsl_rtc.c fsl_sai.c fsl_sai_edma.c fsl_sdhc.c fsl_sim.c fsl_smc.c fsl_sysmpu.c fsl_uart.c fsl_uart_edma.c fsl_vref.c fsl_wdog.c
    device/TOOLCHAIN_ARM_STD/: startup_MK64F12.s
    device/: system_MK64F12.c
  group Finsh
    ../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group Libc
    ../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
  group lwIP
    ../../components/net/lwip/lwip-2.0.3/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../components/net/lwip/lwip-2.0.3/src/apps/ping/: ping.c
    ../../components/net/lwip/lwip-2.0.3/src/core/: def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../components/net/lwip/lwip-2.0.3/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../components/net/lwip/lwip-2.0.3/src/netif/: ethernet.c lowpan6.c
    ../../components/net/lwip/port/: ethernetif.c sys_arch.c
