# Keil uVision project project.uvprojx, settings and files
target RT-Thread (ARM-ADS)
  device: ATSAMD21J18A Atmel
  pack: Keil.SAMD21_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00008000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: RT-Thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __SAMD21J18A__, DEBUG, EXTINT_CALLBACK_MODE=true, RTC_COUNT_ASYNC=true, USART_CALLBACK_MODE=false
  c include: applications;.;board;asflib_config;asflib_config\clock_samd21_r21_da_ha1;sam_d2x_asflib\CMSIS\Include;sam_d2x_asflib\common\utils;sam_d2x_asflib\common\utils\interrupt;sam_d2x_asflib\common\boards;sam_d2x_asflib\common2\services\delay;sam_d2x_asflib\common2\services\delay\sam0;sam_d2x_asflib\sam0;sam_d2x_asflib\sam0\utils;sam_d2x_asflib\sam0\utils\preprocessor;sam_d2x_asflib\sam0\utils\header_files;sam_d2x_asflib\sam0\utils\cmsis\samd21\include;sam_d2x_asflib\sam0\utils\cmsis\samd21\source;sam_d2x_asflib\sam0\drivers\system;sam_d2x_asflib\sam0\drivers\system\pinmux;sam_d2x_asflib\sam0\drivers\system\power\power_sam_d_r_h;sam_d2x_asflib\sam0\drivers\system\reset\reset_sam_d_r_h;sam_d2x_asflib\sam0\drivers\system\clock;sam_d2x_asflib\sam0\drivers\system\interrupt;sam_d2x_asflib\sam0\drivers\system\interrupt\system_interrupt_samd21;sam_d2x_asflib\sam0\drivers\system\clock\clock_samd21_r21_da_ha1;sam_d2x_asflib\sam0\drivers\sercom;sam_d2x_asflib\sam0\drivers\sercom\usart;sam_d2x_asflib\sam0\drivers\port;sam_d2x_asflib\sam0\drivers\rtc;sam_d2x_asflib\sam0\drivers\extint;sam_d2x_asflib\sam0\drivers\extint\extint_sam_d_r_h;..\..\include;..\..\libcpu\arm\cortex-m0;..\..\libcpu\arm\common;..\..\components\drivers\include;..\..\components\drivers\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    applications/: application.c startup.c
  group Board
    board/: board.c sleep_timer.c uart.c
  group Drivers
    sam_d2x_asflib/common/utils/interrupt/: interrupt_sam_nvic.c
    sam_d2x_asflib/sam0/utils/cmsis/samd21/source/: system_samd21.c
    sam_d2x_asflib/sam0/utils/cmsis/samd21/source/arm/: startup_SAMD21.s
    sam_d2x_asflib/sam0/drivers/system/: system.c
    sam_d2x_asflib/sam0/drivers/system/pinmux/: pinmux.c
    sam_d2x_asflib/sam0/drivers/system/interrupt/: system_interrupt.c
    sam_d2x_asflib/sam0/drivers/system/clock/clock_samd21_r21_da_ha1/: clock.c gclk.c
    sam_d2x_asflib/sam0/drivers/sercom/: sercom.c
    sam_d2x_asflib/sam0/drivers/sercom/usart/: usart.c
    sam_d2x_asflib/sam0/drivers/port/: port.c
    sam_d2x_asflib/sam0/drivers/rtc/rtc_sam_d_r_h/: rtc_count.c rtc_count_interrupt.c
    sam_d2x_asflib/sam0/drivers/extint/: extint_callback.c
    sam_d2x_asflib/sam0/drivers/extint/extint_sam_d_r_h/: extint.c
  group Kernel
    ../../src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c object.c scheduler.c signal.c thread.c timer.c
  group CORTEX-M0
    ../../libcpu/arm/cortex-m0/: cpuport.c context_rvds.S
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
  group DeviceDrivers
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/src/: completion.c dataqueue.c pipe.c ringbuffer.c waitqueue.c workqueue.c
