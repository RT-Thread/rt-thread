# Keil uVision project project.uvproj, settings and files
target RT-Thread/SEP4020 (ARM-ADS)
  device: SEP4020 SeuIC
  cpu: IRAM(0x60000000-0x60007FFF) CLOCK(14745600) CPUTYPE(ARM7TDMI)
  output: rtthread-sep4020
  AfterMake: fromelf.exe --bin -o ./build/SEP4020.bin ./build/*.axf
  c flags: Optim=1 wLevel=2
  c include: .;..\..\include;..\..\finsh;..\..\net\lwip\src\include;..\..\net\lwip\src;..\..\net\lwip\src\arch\include;..\..\net\lwip\src\include\ipv4;;..\..\filesystem\dfs;..\..\filesystem\dfs\include;..\..\filesystem\dfs\filesystems\efsl\src\include;..\..\filesystem\dfs\filesystems\efsl\src\base\include;..\..\filesystem\dfs\filesystems\efsl\src\fs\vfat\include;..\..\libcpu\arm\sep4020;..\..\libcpu\arm\sep4020;..\..\components\finsh
  asm define: RAM_INTVEC REMAP
  memory RVCT1: ROM 0x0 size 0x200000
  memory RVCT6: RAM 0x30000000 size 0x2000000
  memory RVCT9: RAM 0x60000000 size 0x8000
  scatter file: .\rtthread-sep4020-sdram.sct
  link misc: --keep __fsym_* --keep __vsym_*
  group bsp
    ./: rtconfig.h application.c board.c startup.c
  group kernel
    ../../src/: clock.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c timer.c scheduler.c slab.c thread.c device.c
  group sep4020
    E:/temp/rt-thread-sep4020/libcpu/arm/sep4020/: interrupt.c stack.c trap.c cpu.c start_rvds.S context_rvds.S
    ../../libcpu/arm/sep4020/: clk.c serial.c serial.h
  group finsh
    ../../components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c shell.c symbol.c
  group lwip
    ../../net/lwip/src/core/: dhcp.c dns.c init.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c memp.c
    ../../net/lwip/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../net/lwip/src/core/snmp/: asn1_dec.c asn1_enc.c mib2.c mib_structs.c msg_in.c msg_out.c
    ../../net/lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c tcpip.c sockets.c
    ../../net/lwip/src/netif/: etharp.c ethernetif.c loopif.c
    ../../net/lwip/src/arch/: sys_arch_init.c sys_arch.c
  group filesystem
    ../../filesystem/dfs/src/: dfs_util.c dfs_cache.c dfs_fs.c dfs_init.c dfs_raw.c dfs_posix.c
    ../../filesystem/dfs/filesystems/efsl/src/base/: plibc.c efs.c extract.c partition.c
    ../../filesystem/dfs/filesystems/efsl/src/fs/vfat/: ui.c dir.c fat.c file.c fs.c ls.c time.c
