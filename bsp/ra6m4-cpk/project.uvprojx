# Keil uVision project project.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: R7FA6M4AF Renesas
  pack: Renesas.RA_DFP.3.1.0
  cpu: CPUTYPE("Cortex-M33") FPU2 CLOCK(12000000) ELITTLE
  output: ra6m4 +hex
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3
  c define: SOC_R7FA6M4AF, __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND
  c misc: -Wno-license-management -Wuninitialized -Wall -Wmissing-declarations -Wpointer-arith -Waggregate-return -Wfloat-equal
  c include: ..\..\libcpu\arm\common;..\..\libcpu\arm\cortex-m4;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\drivers\include;drivers;drivers\config;..\..\components\finsh;.;..\..\include;..\..\components\libc\compilers\common;..\..\components\libc\compilers\common\none-gcc;..\..\examples\utest\testcases\kernel
  library: MicroLIB
  scatter file: .\script\fsp.scat
  group CPU
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../components/drivers/misc/: pin.c
    ../../components/drivers/serial/: serial_v2.c
    ../../components/drivers/src/: pipe.c ringblk_buf.c dataqueue.c workqueue.c ringbuffer.c completion.c waitqueue.c
  group Drivers
    drivers/: drv_gpio.c drv_usart_v2.c drv_common.c
  group Finsh
    ../../components/finsh/: shell.c msh.c cmd.c
  group Kernel
    ../../src/: ipc.c thread.c device.c kservice.c components.c clock.c timer.c mem.c object.c scheduler.c irq.c idle.c
  group libc
    ../../components/libc/compilers/common/: time.c
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_entry.c SConscript
software components: Flex Software:RA Configuration 1.0.0
