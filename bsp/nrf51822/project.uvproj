# Keil uVision project project.uvproj, settings and files
target rt-thread (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.4
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: template
  c flags: Optim=1 OneElfS=1
  c define: NRF51, USE_STDPERIPH_DRIVER
  c misc: --c99
  c include: Libraries/CMSIS/Include;Libraries/nrf51822/Include;applications;.;drivers;../../include;../../libcpu/arm/cortex-m0;../../libcpu/arm/common;../../components/drivers/include;../../components/finsh
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --keep *.o(FSymTab)
  group Startup Code
    Libraries/nrf51822/Source/templates/: system_nrf51.c
    Libraries/nrf51822/Source/templates/arm/: arm_startup_nrf51.s
  group Applications
    applications/: application.c startup.c
  group Drivers
    drivers/: board.c uart.c
  group Kernel
    ../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c object.c scheduler.c thread.c timer.c
  group CORTEX-M0
    ../../libcpu/arm/cortex-m0/: cpuport.c context_rvds.S
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
  group DeviceDrivers
    ../../components/drivers/src/: completion.c portal.c ringbuffer.c workqueue.c
  group finsh
    ../../components/finsh/: shell.c symbol.c cmd.c msh_cmd.c msh.c
