# IAR project project.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M2354 series Nuvoton M2354 series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 58
  General.FPU2: 0
  ICCARM.CCDefines: ARM_MATH_ARMV8MBL; CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; _DLIB_FILE_DESCRIPTOR; __RTTHREAD__; __RT_IPC_SOURCE__; __RT_KERNEL_SOURCE__
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: ..\..\..\components\drivers\sdio\sdhci\include; ..\..\..\components\net\sal\include; ..\..\..\libcpu\arm\common; ..\..\..\components\drivers\audio; .; ..\..\..\components\libc\compilers\common\extension; ..\..\..\components\net\at\include; ..\..\..\components\dfs\dfs_v1\include; ..\..\..\components\dfs\dfs_v1\filesystems\devfs; ..\..\..\components\libc\posix\io\epoll; ..\..\..\components\drivers\include; ..\..\..\components\legacy\usb\usbhost\class; ..\..\..\components\dfs\dfs_v1\filesystems\elmfat; ..\..\..\components\legacy\include; ..\..\..\libcpu\arm\cortex-m23; board\NuPinConfig; ..\..\..\components\legacy\usb\usbhost; ..\libraries\m2354\StdDriver\inc; ..\..\..\components\legacy\usb\usbhost\include; ..\..\..\components\drivers\hwcrypto; ..\libraries\m2354\USBHostLib\inc; ..\..\..\components\fal\inc; ..\..\..\components\net\at\at_socket; ..\libraries\nu_packages\NuUtils\inc; ..\libraries\nu_packages\SLCD; ..\..\..\components\drivers\spi\sfud\inc; ..\..\..\components\utilities\utest; ..\..\..\components\drivers\phy; ..\..\..\components\drivers\smp_call; ..\..\..\components\net\sal\include\socket\sys_socket; ..\..\..\components\legacy\usb\usbhost\core; ..\..\..\components\net\sal\include\socket; ..\..\..\components\libc\compilers\common\include; ..\..\..\components\finsh; ..\..\..\components\net\sal\impl; ..\..\..\components\libc\posix\io\poll; ..\..\..\components\legacy\usb\usbdevice; board\NuClockConfig; ..\..\..\components\drivers\spi; ..\libraries\m2354\rtt_port; ..\..\..\components\net\sal\include\dfs_net; ..\libraries\nu_packages\Demo; ..\..\..\components\net\netdev\include; ..\libraries\m2354\Device\Nuvoton\M2354\Include; applications; ..\..\..\components\libc\posix\io\eventfd; ..\..\..\include; board; ..\libraries\nu_packages\TPC; ..\..\..\components\libc\compilers\common\extension\fcntl\octal; ..\libraries\m2354\CMSIS\Include; ..\..\..\components\libc\posix\ipc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: rtthread.bin
  ILINK.IlinkOutputFile: Template.out
  ILINK.IlinkIcfFile: linking_scripts\m2354_flash.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCOptLevel: 1
  group Applications
    applications/: main.c mnt.c
  group AT
    ../../../components/net/at/at_socket/: at_socket.c
    ../../../components/net/at/src/: at_client.c at_utils.c at_cli.c
  group board
    board/NuPinConfig/: nutool_pincfg.c
    board/: board_dev.c
    board/NuClockConfig/: nutool_modclkcfg.c
  group Compiler
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
  group DeviceDrivers
    ../../../components/drivers/audio/: dev_audio.c dev_audio_pipe.c
    ../../../components/drivers/can/: dev_can.c
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/hwcrypto/: hw_crc.c hw_hash.c hw_rng.c hw_symmetric.c hwcrypto.c
    ../../../components/drivers/hwtimer/: hwtimer.c
    ../../../components/drivers/i2c/: dev_i2c_bit_ops.c dev_i2c_core.c dev_i2c_dev.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/misc/: adc.c rt_drv_pwm.c
    ../../../components/drivers/pin/: dev_pin.c
    ../../../components/drivers/pm/: lptimer.c pm.c
    ../../../components/drivers/rtc/: dev_rtc.c
    ../../../components/drivers/sdio/: dev_block.c dev_mmc.c dev_mmcsd_core.c dev_sd.c dev_sdio.c
    ../../../components/drivers/sensor/v1/: sensor.c sensor_cmd.c
    ../../../components/drivers/serial/: dev_serial.c
    ../../../components/drivers/spi/: dev_qspi_core.c dev_spi.c dev_spi_core.c dev_spi_flash_sfud.c
    ../../../components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    ../../../components/drivers/watchdog/: dev_watchdog.c
  group Drivers
    ../libraries/m2354/Device/Nuvoton/M2354/Source/IAR/: startup_M2354.s
    ../libraries/m2354/Device/Nuvoton/M2354/Source/: system_M2354.c
    ../libraries/m2354/rtt_port/: drv_bpwm.c drv_bpwm_capture.c drv_can.c drv_clk.c drv_common.c drv_crc.c drv_crypto.c drv_eadc.c drv_ebi.c drv_ecap.c drv_epwm.c drv_epwm_capture.c drv_fmc.c drv_gpio.c drv_i2c.c drv_i2s.c drv_otg.c drv_pdma.c drv_qei.c drv_qspi.c drv_rtc.c drv_scuart.c drv_sdh.c drv_sdio.c drv_slcd.c drv_softi2c.c drv_spi.c drv_spii2s.c drv_timer.c drv_timer_capture.c drv_tpwm.c drv_trng.c drv_uart.c drv_ui2c.c drv_usbd.c drv_usbhost.c drv_uspi.c drv_uuart.c drv_wdt.c
  group Fal
    ../../../components/fal/src/: fal_flash.c fal_partition.c fal_rtt.c fal.c
  group Filesystem
    ../../../components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    ../../../components/dfs/dfs_v1/filesystems/elmfat/: dfs_elm.c ff.c ffunicode.c
    ../../../components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    ../../../components/finsh/: msh_parse.c msh.c shell.c msh_file.c cmd.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c signal.c thread.c timer.c
  group klibc
    ../../../src/klibc/: kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c kerrno.c
  group libcpu
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m23/: context_iar.S cpuport.c
  group Libraries
    ../libraries/m2354/StdDriver/src/: nu_clk.c nu_spi.c nu_rtc.c nu_uart.c nu_pdma.c nu_ewwdt.c nu_timer.c nu_fvc.c nu_crypto.c nu_ebi.c nu_acmp.c nu_tamper.c nu_sc.c nu_wdt.c nu_qei.c nu_usci_uart.c nu_i2s.c nu_scuart.c nu_qspi.c nu_eadc.c nu_ewdt.c nu_timer_pwm.c nu_gpio.c nu_epwm.c nu_ecap.c nu_usci_spi.c nu_bpwm.c nu_usci_i2c.c nu_sys.c nu_wwdt.c nu_dpm.c nu_lcd.c nu_rng.c nu_crc.c nu_i2c.c nu_trng.c nu_keystore.c nu_dac.c nu_fmc.c nu_usbd.c nu_sdh.c nu_can.c
  group m2354_usbhostlib
    ../libraries/m2354/USBHostLib/src/: mem_alloc.c ohci.c usb_core.c
  group nu_pkgs_demo
    ../libraries/nu_packages/Demo/: atdev_utils.c slcd_show_tick.c smp_demo.c ccap_demo.c ccap_saver.c wormhole_demo.c usbd_hid_dance_mouse.c usbd_cdc_vcom_echo.c hwsem_counter.c
  group nu_pkgs_slcd
    ../libraries/nu_packages/SLCD/: slcd_rhe6616tp01.c
  group POSIX
    ../../../components/libc/posix/io/poll/: poll.c select.c
  group rt_usbd
    ../../../components/legacy/usb/usbdevice/core/: usbdevice.c usbdevice_core.c
    ../../../components/legacy/usb/usbdevice/class/: hid.c
  group rt_usbh
    ../../../components/legacy/usb/usbhost/class/: udisk.c mass.c
    ../../../components/legacy/usb/usbhost/core/: usbhost_core.c usbhost.c driver.c hub.c
  group SAL
    ../../../components/net/netdev/src/: netdev.c netdev_ipaddr.c
    ../../../components/net/sal/dfs_net/: dfs_net.c
    ../../../components/net/sal/impl/: af_inet_at.c
    ../../../components/net/sal/socket/: net_netdb.c net_sockets.c
    ../../../components/net/sal/src/: sal_socket.c
  group UTest
    ../../../components/utilities/utest/: TC_uassert.c utest.c
