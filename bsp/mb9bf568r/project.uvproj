# Keil uVision project project.uvproj, settings and files
target rtthread-fm4 (ARM-ADS)
  device: Cortex-M4 FPU ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: template_mb9b56xx
  c flags: Optim=1
  c define: __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND
  c include: applications;.;CMSIS\Include;CMSIS\DeviceSupport;..\..\libcpu\arm\common;..\..\libcpu\arm\cortex-m4;drivers;..\..\components\finsh;.;..\..\include;..\..\components\libc\compilers\common;..\..\components\libc\compilers\common\nogcc;..\..\examples\utest\testcases\kernel
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT5: ROM 0x200c0000 size 0x8000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20038000 size 0x10000
  group Applications
    applications/: application.c startup.c
  group CMSIS
    CMSIS/DeviceSupport/arm/: startup_mb9bf56xr.s
    CMSIS/DeviceSupport/: system_mb9abxxx.c
  group CPU
    ../../libcpu/arm/common/: showmem.c backtrace.c div0.c
    ../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group Drivers
    drivers/: led.c board.c serial.c
  group Finsh
    ../../components/finsh/: shell.c msh.c
  group Kernel
    ../../src/: kservice.c timer.c idle.c thread.c ipc.c device.c object.c mempool.c mem.c components.c clock.c scheduler.c irq.c
