# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L431RCTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00004000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: RT_USING_ARM_LIBC, USE_HAL_DRIVER, __RTTHREAD__, STM32L431xx, __CLK_TCK=RT_TICK_PER_SECOND
  c include: .;applications;..\..\..\libcpu\arm\common;..\..\..\libcpu\arm\cortex-m4;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\spi;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;board;board\CubeMX_Config\Inc;board\ports\lcd;..\libraries\HAL_Drivers;..\libraries\HAL_Drivers\config;..\..\..\components\finsh;.;..\..\..\include;..\..\..\components\libc\compilers\armlibc;..\..\..\components\libc\compilers\common;..\..\..\components\libc\compilers\common\nogcc;..\libraries\STM32L4xx_HAL\STM32L4xx_HAL_Driver\Inc;..\libraries\STM32L4xx_HAL\CMSIS\Device\ST\STM32L4xx\Include;..\libraries\STM32L4xx_HAL\CMSIS\Include;..\..\..\examples\utest\testcases\kernel
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x4000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group CPU
    ../../../libcpu/arm/common/: backtrace.c showmem.c div0.c
    ../../../libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
  group DeviceDrivers
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/rtc/: rtc.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/spi/: spi_core.c spi_dev.c
    ../../../components/drivers/src/: ringblk_buf.c completion.c workqueue.c pipe.c dataqueue.c ringbuffer.c waitqueue.c
    ../../../components/drivers/watchdog/: watchdog.c
  group Drivers
    ../libraries/STM32L4xx_HAL/CMSIS/Device/ST/STM32L4xx/Source/Templates/arm/: startup_stm32l431xx.s
    board/ports/lcd/: drv_lcd.c
    board/CubeMX_Config/Src/: stm32l4xx_hal_msp.c
    board/: board.c
    ../libraries/HAL_Drivers/: drv_gpio.c drv_usart.c drv_common.c drv_spi.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c cmd.c
  group Kernel
    ../../../src/: scheduler.c idle.c thread.c kservice.c mempool.c mem.c irq.c object.c components.c device.c ipc.c clock.c timer.c
  group libc
    ../../../components/libc/compilers/armlibc/: mem_std.c syscalls.c libc.c
    ../../../components/libc/compilers/common/: time.c stdlib.c
  group Libraries
    ../libraries/STM32L4xx_HAL/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_cryp.c stm32l4xx_hal_spi.c stm32l4xx_hal_cortex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_wwdg.c stm32l4xx_hal_rtc.c stm32l4xx_hal_pwr.c stm32l4xx_hal_usart_ex.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_usart.c stm32l4xx_hal_cryp_ex.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_comp.c stm32l4xx_hal_iwdg.c stm32l4xx_hal_qspi.c stm32l4xx_hal_exti.c stm32l4xx_hal_rng.c stm32l4xx_hal_crc.c stm32l4xx_hal_uart_ex.c
    ../libraries/STM32L4xx_HAL/CMSIS/Device/ST/STM32L4xx/Source/Templates/: system_stm32l4xx.c
