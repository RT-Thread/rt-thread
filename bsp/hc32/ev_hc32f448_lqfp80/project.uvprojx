# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: HC32F448MCTI HDSC
  pack: HDSC.HC32F448.1.0.0
  cpu: IROM1(0x00000000,0x40000) IROM2(0x03000C00,0x400) IRAM1(0x1FFF8000,0x10000) IRAM2(0x200F0000,0x1000) CPUTYPE("Cortex-M4") FPU2 CLOCK(8000000) ESEL ELITTLE
  output: rt-thread +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: RT_USING_LIBC, __RTTHREAD__, RT_USING_ARMLIBC, __DEBUG, __CLK_TCK=RT_TICK_PER_SECOND, __STDC_LIMIT_MACROS, USE_DDL_DRIVER, HC32F448
  c include: board\config;..\..\..\components\drivers\include;.;..\..\..\components\libc\posix\ipc;packages\hc32-f4-series\hc32f448\inc;..\libraries\hc32f448_ddl\hc32_ll_driver\inc;..\tests;..\..\..\components\drivers\include;board\ports;..\libraries\hc32_drivers;packages\hc32-f4-cmsis\Device\HDSC\hc32f448\Include;..\..\..\components\drivers\include;..\platform\tca9539;..\..\..\libcpu\arm\cortex-m4;..\..\..\components\libc\compilers\common\extension\fcntl\octal;Include;..\..\..\components\libc\posix\io\poll;..\..\..\components\drivers\phy;..\..\..\components\libc\posix\io\eventfd;..\..\..\components\libc\compilers\common\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\libc\posix\io\epoll;..\..\..\components\finsh;..\..\..\include;..\libraries\hc32f448_ddl\cmsis\Include;..\..\..\libcpu\arm\common;..\..\..\components\libc\compilers\common\extension;applications;..\..\..\components\drivers\include;board;..\libraries\hc32f448_ddl\cmsis\Device\HDSC\hc32f4xx\Include;..\..\..\components\drivers\smp_call
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x3000c00 size 0x400
  memory RVCT9: RAM 0x1fff8000 size 0x10000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c xtal32_fcm.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/i2c/: dev_i2c_bit_ops.c dev_i2c_core.c dev_i2c_dev.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/pin/: dev_pin.c
    ../../../components/drivers/serial/: dev_serial.c
  group Drivers
    board/: board.c board_config.c
    ../libraries/hc32f448_ddl/cmsis/Device/HDSC/hc32f4xx/Source/ARM/: startup_hc32f448.s
    ../libraries/hc32_drivers/: drv_common.c drv_gpio.c drv_i2c.c drv_irq.c drv_soft_i2c.c drv_usart.c
  group Finsh
    ../../../components/finsh/: cmd.c msh.c shell.c msh_parse.c
  group HC32F448-LL
    packages/hc32-f4-series/hc32f448/src/: hc32_ll_pwc.c hc32_ll_fcm.c hc32_ll_utility.c hc32_ll_tmr0.c hc32_ll_interrupts.c hc32_ll_fcg.c hc32_ll_efm.c hc32_ll_gpio.c hc32_ll_usart.c hc32_ll.c hc32_ll_i2c.c hc32_ll_icg.c hc32_ll_clk.c hc32_ll_dma.c hc32_ll_sram.c hc32_ll_aos.c hc32_ll_rmu.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    ../../../src/klibc/: kerrno.c kstdio.c rt_vsscanf.c kstring.c rt_vsnprintf_tiny.c
  group libcpu
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group Libraries
    packages/hc32-f4-cmsis/Device/HDSC/hc32f448/Source/ARM/: startup_hc32f448.s
    packages/hc32-f4-cmsis/Device/HDSC/hc32f448/Source/: system_hc32f448.c
    ../libraries/hc32f448_ddl/cmsis/Device/HDSC/hc32f4xx/Source/: system_hc32f448.c
    ../libraries/hc32f448_ddl/hc32_ll_driver/src/: hc32_ll.c hc32_ll_aos.c hc32_ll_clk.c hc32_ll_dma.c hc32_ll_efm.c hc32_ll_fcg.c hc32_ll_fcm.c hc32_ll_gpio.c hc32_ll_i2c.c hc32_ll_icg.c hc32_ll_interrupts.c hc32_ll_pwc.c hc32_ll_rmu.c hc32_ll_sram.c hc32_ll_tmr0.c hc32_ll_usart.c hc32_ll_utility.c
  group Platform
    ../platform/tca9539/: tca9539.c
  group Tests
    ../tests/: test_gpio.c test_soft_i2c.c test_i2c.c test_uart_v1.c
