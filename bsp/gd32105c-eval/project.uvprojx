# Keil uVision project project.uvprojx, settings and files
target rt-thread_gd32f105 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: GD32F105VC GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.3
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: GD32F10X_CL, __STDC_LIMIT_MACROS, RT_USING_ARMLIBC, USE_STDPERIPH_DRIVER, RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND, __RTTHREAD__
  c include: ..\..\components\drivers\include;..\..\components\dfs\filesystems\devfs;..\..\components\libc\compilers\common\extension;..\..\libcpu\arm\cortex-m3;..\..\include;..\..\components\finsh;..\..\components\drivers\include;..\..\components\drivers\spi;Libraries\CMSIS;..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\components\libc\posix\io\stdio;Libraries\GD32F10x_standard_peripheral\Include;..\..\components\dfs\filesystems\elmfat;.;..\..\components\drivers\include;..\..\components\dfs\include;..\..\components\drivers\include;..\..\libcpu\arm\common;Libraries\CMSIS\GD\GD32F10x\Include;applications;..\..\components\libc\posix\ipc;..\..\components\drivers\include;..\..\components\libc\posix\io\poll;..\..\components\libc\compilers\common\include;..\..\components\drivers\spi\sfud\inc;drivers
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Applications
    applications/: main.c
  group Compiler
    ../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../components/libc/compilers/common/: cctype.c cstdio.c cstdlib.c cstring.c ctime.c cwchar.c
  group CPU
    ../../libcpu/arm/common/: div0.c showmem.c
    ../../libcpu/arm/cortex-m3/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../components/drivers/i2c/: i2c_core.c i2c_dev.c
    ../../components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../components/drivers/misc/: pin.c
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    ../../components/drivers/spi/: spi_core.c spi_dev.c spi_flash_sfud.c
  group Drivers
    drivers/: drv_gpio.c drv_spi.c drv_i2c.c drv_spi_flash.c drv_usart.c board.c
  group Filesystem
    ../../components/dfs/filesystems/devfs/: devfs.c
    ../../components/dfs/filesystems/elmfat/: dfs_elm.c ff.c ffunicode.c
    ../../components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    ../../components/finsh/: shell.c msh.c msh_parse.c cmd.c msh_file.c
  group Kernel
    ../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_up.c thread.c timer.c
  group Libraries
    Libraries/GD32F10x_standard_peripheral/Source/: gd32f10x_fmc.c gd32f10x_usart.c gd32f10x_dma.c gd32f10x_pmu.c gd32f10x_wwdgt.c gd32f10x_dac.c gd32f10x_bkp.c gd32f10x_exti.c gd32f10x_timer.c gd32f10x_can.c gd32f10x_enet.c gd32f10x_sdio.c gd32f10x_dbg.c gd32f10x_fwdgt.c gd32f10x_i2c.c gd32f10x_gpio.c gd32f10x_spi.c gd32f10x_misc.c gd32f10x_adc.c gd32f10x_rtc.c gd32f10x_crc.c gd32f10x_rcu.c gd32f10x_exmc.c
    Libraries/CMSIS/GD/GD32F10x/Source/: system_gd32f10x.c
    Libraries/CMSIS/GD/GD32F10x/Source/ARM/: startup_gd32f10x_cl.s
