# Keil uVision project project.uvprojx, settings and files
target rtthread-frdm-mcxe247 (6230000::V6.23::ARMCLANG)
  device: MCXE247VLQ NXP
  pack: NXP.MCXE247_DFP.25.06.00
  cpu: IRAM(0x14000000,0x1000) IRAM2(0x1ffe0000,0x020000) IROM(0x10000000,0x080000) IROM2(0x00000000,0x180000) XRAM(0x20000000,0x01f000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rtthread
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=3
  c define: __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND, __STDC_LIMIT_MACROS, RT_USING_ARMLIBC, CPU_MCXE247VLQ, RT_USING_LIBC, DEBUG
  c misc: --target=arm-arm-none-eabi
  c include: ..\..\..\..\..\libcpu\arm\cortex-m4;..\..\..\..\..\components\drivers\include;..\libraries\drivers\config;..\..\..\..\..\components\drivers\spi;..\..\..\..\..\components\dfs\dfs_v1\include;..\..\..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\..\..\components\dfs\dfs_v1\filesystems\devfs;..\..\..\..\..\include;packages\nxp-mcx-series-latest\MCXE247\drivers;..\..\..\..\..\components\libc\posix\io\eventfd;applications;..\..\..\..\..\components\drivers\smp_call;..\..\..\..\..\components\libc\posix\ipc;..\..\..\..\..\components\drivers\include;..\libraries\drivers;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\drivers\include;board;..\..\..\..\..\components\libc\posix\io\epoll;..\..\..\..\..\components\drivers\include;packages\nxp-mcx-cmsis-latest\Core\Include;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\libc\compilers\common\extension;..\..\..\..\..\components\libc\posix\io\poll;..\..\..\..\..\components\drivers\phy;board\MCUX_Config\board;..\..\..\..\..\components\libc\compilers\common\include;..\..\..\..\..\components\drivers\include;..\..\..\..\..\libcpu\arm\common;packages\nxp-mcx-series-latest\MCXE247;..\..\..\..\..\components\finsh;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\drivers\include;packages\nxp-mcx-series-latest\MCXE247\periph0;.
  asm misc: -x assembler-with-cpp
  memory RVCT4: ROM 0x10000000 size 0x80000
  memory RVCT5: ROM 0x0 size 0x180000
  memory RVCT6: RAM 0x20000000 size 0x1f000
  memory RVCT9: RAM 0x14000000 size 0x1000
  memory RVCT10: RAM 0x1ffe0000 size 0x20000
  scatter file: .\board\linker_scripts\MCXE247_flash.scf
  group Applications
    applications/: drv_spi_sample_rw007.c main.c
  group Compiler
    ../../../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../../../components/drivers/core/: device.c
    ../../../../../components/drivers/clock_time/: clock_timer.c
    ../../../../../components/drivers/i2c/: dev_i2c_bit_ops.c dev_i2c_core.c dev_i2c_dev.c
    ../../../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../../components/drivers/misc/: adc.c
    ../../../../../components/drivers/pin/: dev_pin.c
    ../../../../../components/drivers/rtc/: dev_rtc.c
    ../../../../../components/drivers/serial/: dev_serial.c
    ../../../../../components/drivers/spi/: dev_spi.c dev_spi_core.c
  group Drivers
    board/MCUX_Config/board/: clock_config.c pin_mux.c
    board/: board.c
    ../libraries/drivers/: drv_pin.c drv_uart.c
  group Filesystem
    ../../../../../components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    ../../../../../components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    ../../../../../components/finsh/: shell.c cmd.c msh_parse.c msh_file.c msh.c
  group Kernel
    ../../../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    ../../../../../src/klibc/: kstring.c rt_vsscanf.c rt_vsnprintf_tiny.c kstdio.c kerrno.c
  group libcpu
    ../../../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group Libraries
    packages/nxp-mcx-series-latest/MCXE247/arm/: startup_MCXE247.S
    packages/nxp-mcx-series-latest/MCXE247/drivers/: ela_csec_driver.c ela_csec_hw_access.c fsl_acmp.c fsl_adc12.c fsl_clock.c fsl_common.c fsl_common_arm.c fsl_crc.c fsl_dmamux.c fsl_edma.c fsl_enet.c fsl_ewm.c fsl_flexcan.c fsl_flexcan_edma.c fsl_flexcan_soc.c fsl_flexio.c fsl_flexio_i2c_master.c fsl_flexio_spi.c fsl_flexio_spi_edma.c fsl_flexio_uart.c fsl_flexio_uart_edma.c fsl_ftfx_cache.c fsl_ftfx_controller.c fsl_ftfx_flash.c fsl_ftfx_flexnvm.c fsl_ftm.c fsl_gpio.c fsl_lpi2c.c fsl_lpi2c_edma.c fsl_lpit.c fsl_lpspi.c fsl_lpspi_edma.c fsl_lptmr.c fsl_lpuart.c fsl_lpuart_edma.c fsl_pdb.c fsl_pmc.c fsl_qspi.c fsl_qspi_edma.c fsl_qspi_soc.c fsl_rcm.c fsl_rtc.c fsl_sim.c fsl_smc.c fsl_sysmpu.c fsl_trgmux.c fsl_wdog32.c
    packages/nxp-mcx-series-latest/MCXE247/drivers/lmem/: fsl_cache.c
    packages/nxp-mcx-series-latest/MCXE247/: system_MCXE247.c
