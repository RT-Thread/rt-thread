# Keil uVision project template.uvprojx, settings and files
target Target_1 (ARM-ADS)
  device: R7FA4E2B9 Renesas
  pack: Renesas.RA_DFP.5.9.0
  cpu: CPUTYPE("Cortex-M33") DSP TZ  FPU3(SFPU)  CLOCK(12000000) ELITTLE
  output: rtthread +hex
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3
  c misc: -Wno-license-management -Wuninitialized -Wall -Wmissing-declarations -Wpointer-arith -Waggregate-return -Wfloat-equal
  scatter file: .\script\fsp.scat
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_entry.c
software components: Flex Software:RA Configuration 1.0.0
