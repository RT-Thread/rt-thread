# IAR project fm3_easy_kit.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MB9BF506R Fujitsu MB9BF506R
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ; ..\CMSIS; ..\..\..\include; ..\..\..\components\finsh
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: fm3_easy_kit.out
  ILINK.IlinkIcfFile: mb9bf506.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS
    ../CMSIS/: core_cm3.c system_mb9bf50x.c
  group Finsh
    ../../../components/finsh/: cmd.c finsh.h finsh_compiler.c finsh_error.c finsh_error.h finsh_heap.c finsh_heap.h finsh_init.c finsh_node.c finsh_node.h finsh_ops.c finsh_ops.h finsh_parser.c finsh_parser.h finsh_token.c finsh_token.h finsh_var.c finsh_var.h finsh_vm.c finsh_vm.h shell.c shell.h symbol.c
  group FM3
    ../../../libcpu/arm/fm3/: context_iar.S cpuport.c fault_iar.S start_iar.S
  group Kernel
    ../../../src/: clock.c device.c idle.c ipc.c irq.c kservice.c kservice.h mem.c mempool.c module.c module.h object.c rtm.c scheduler.c slab.c thread.c timer.c
  group Startup
    ./: application.c board.c console.c led.c serial.c startup.c
