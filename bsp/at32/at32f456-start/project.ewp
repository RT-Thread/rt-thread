# IAR project project.ewp, settings and files
configuration rt-thread (ARM, debug)
  General.OGChipSelectEditMenu: AT32F456ZET7_v2 ArteryTek AT32F456ZET7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: AT32F456ZET7; __RTTHREAD__; CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; __RT_IPC_SOURCE__; __RT_KERNEL_SOURCE__
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: applications; ..\..\..\libcpu\arm\common; ..\..\..\libcpu\arm\cortex-m4; ..\..\..\components\drivers\include; ..\..\..\components\drivers\phy; ..\..\..\components\drivers\smp_call; board; board\inc; ..\libraries\rt_drivers; ..\libraries\rt_drivers\config; ..\..\..\components\finsh; .; ..\..\..\include; ..\..\..\components\libc\compilers\common\include; ..\..\..\components\libc\compilers\common\extension; ..\..\..\components\libc\compilers\common\extension\fcntl\octal; ..\..\..\components\libc\posix\io\epoll; ..\..\..\components\libc\posix\io\eventfd; ..\..\..\components\libc\posix\io\poll; ..\..\..\components\libc\posix\ipc; ..\libraries\usbotg_library\inc; ..\..\..\components\net\utest
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../../rtthread.bin
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: main.c
  group CPU
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m4/: context_iar.S cpuport.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/pin/: dev_pin.c
    ../../../components/drivers/serial/: dev_serial_v2.c
  group Drivers
    board/src/: at32_msp.c board.c
    ../libraries/rt_drivers/: drv_common.c drv_gpio.c drv_usart_v2.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group Libc
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
    ../../../src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
