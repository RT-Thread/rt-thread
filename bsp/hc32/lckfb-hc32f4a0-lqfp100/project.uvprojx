# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060960::V5.06 update 7 (build 960)::.\ac5)
  device: HC32F4A0PITB HDSC
  pack: HDSC.HC32F4A0.1.0.5
  cpu: IRAM(0x1FFE0000,0x80000) IROM(0x00000000,0x200000) IROM2(0x03000000,0x1800) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rt-thread +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: RT_USING_ARMLIBC, __DEBUG, __STDC_LIMIT_MACROS, HC32F4A0, __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND, RT_USING_LIBC, USE_DDL_DRIVER
  c include: ..\..\..\components\drivers\include;..\libraries\hc32f4a0_ddl\drivers\cmsis\Device\HDSC\hc32f4xx\Include;..\libraries\hc32_drivers;..\libraries\hc32f4a0_ddl\drivers\cmsis\Include;board\config\usb_config;applications;..\..\..\libcpu\arm\cortex-m4;board;..\..\..\components\libc\compilers\common\include;..\..\..\components\drivers\include;..\..\..\components\finsh;.;..\..\..\components\libc\posix\io\epoll;..\..\..\include;..\..\..\components\libc\posix\ipc;..\..\..\components\libc\compilers\common\extension;..\..\..\components\libc\posix\io\poll;board\ports;..\..\..\components\libc\posix\io\eventfd;..\..\..\libcpu\arm\common;..\..\..\components\drivers\include;board\config;..\libraries\hc32f4a0_ddl\drivers\hc32_ll_driver\inc;..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\components\drivers\include
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x3000000 size 0x1800
  memory RVCT9: RAM 0x1ffe0000 size 0x80000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: xtal32_fcm.c main.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/pin/: pin.c
    ../../../components/drivers/serial/: serial.c
  group Drivers
    board/: board.c board_config.c
    ../libraries/hc32f4a0_ddl/drivers/cmsis/Device/HDSC/hc32f4xx/Source/ARM/: startup_hc32f4a0.s
    ../libraries/hc32_drivers/: drv_common.c drv_gpio.c drv_irq.c drv_usart.c
  group Finsh
    ../../../components/finsh/: shell.c msh_parse.c msh.c cmd.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
    ../../../src/klibc/: kstdio.c kstring.c
  group libcpu
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group Libraries
    ../libraries/hc32f4a0_ddl/drivers/hc32_ll_driver/src/: hc32_ll_efm.c hc32_ll_clk.c hc32_ll_fcg.c hc32_ll_aos.c hc32_ll_dma.c hc32_ll_gpio.c hc32_ll_interrupts.c hc32_ll_usart.c hc32_ll_tmr0.c hc32_ll_utility.c hc32_ll_icg.c hc32_ll.c hc32f4a0_ll_interrupts_share.c hc32_ll_sram.c hc32_ll_rmu.c hc32_ll_pwc.c
    ../libraries/hc32f4a0_ddl/drivers/cmsis/Device/HDSC/hc32f4xx/Source/: system_hc32f4a0.c
