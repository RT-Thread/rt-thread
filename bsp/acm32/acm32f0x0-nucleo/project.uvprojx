# Keil uVision project project.uvprojx, settings and files
target ACM32F0x0 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: ACM32F0x0 +hex
  AfterMake: fromelf.exe --bin --output rtthread.bin ./build/keil/Obj/acm32f030.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: __RTTHREAD__, RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND, RT_USING_ARMLIBC, __STDC_LIMIT_MACROS
  c include: libraries\CMSIS;..\..\..\components\libc\compilers\common\extension;..\..\..\components\finsh;libraries\Device;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\clock_time;..\..\..\libcpu\arm\common;..\..\..\components\drivers\smp_call;..\..\..\include;.;..\..\..\components\drivers\include;drivers;..\..\..\libcpu\arm\cortex-m0;..\..\..\components\drivers\include;..\..\..\components\libc\posix\ipc;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\components\libc\compilers\common\include;libraries\HAL_Driver\Inc;..\..\..\components\drivers\phy;..\..\..\components\net\utest;..\..\..\components\drivers\include;applications;..\..\..\components\libc\posix\io\eventfd;..\..\..\components\libc\posix\io\poll;..\..\..\components\drivers\include;..\..\..\components\libc\posix\io\epoll
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\drivers\linker_scripts\link.sct
  group ACM32_HAL
    libraries/Device/: System_ACM32F0x0.c Startup_ACM32F0x0.s
    libraries/HAL_Driver/Src/: HAL_DMA.c HAL_ADC.c HAL_GPIO.c HAL_WDT.c HAL_IWDT.c HAL_UART.c HAL_TIMER.c HAL_EXTI.c HAL_RTC.c HAL_SPI.c HAL_I2C.c HAL_CRC.c
  group Applications
    applications/: main.c
  group CPU
    ../../../libcpu/arm/common/: div0.c showmem.c
    ../../../libcpu/arm/cortex-m0/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../../components/drivers/clock_time/: clock_boottime.c clock_hrtimer.c clock_time_core.c clock_timer.c
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/misc/: adc.c
    ../../../components/drivers/pin/: dev_pin.c
    ../../../components/drivers/serial/: dev_serial.c
    ../../../components/drivers/watchdog/: dev_watchdog.c
  group Drivers
    drivers/: board.c drv_adc.c drv_gpio.c drv_i2c.c drv_pm.c drv_rtc.c drv_soft_i2c.c drv_spi.c drv_timer.c drv_uart.c drv_wdt.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group Libc
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
