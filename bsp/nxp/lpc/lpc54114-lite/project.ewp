# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC54114J256_M4 NXP LPC54114J256_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; _DLIB_FILE_DESCRIPTOR; __RTTHREAD__; SDK_DEBUGCONSOLE=0; CORE_M4; CPU_LPC54114; CPU_LPC54114J256BD64_cm4=1; __RT_IPC_SOURCE__; __RT_KERNEL_SOURCE__
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\components\libc\compilers\common\extension; Libraries\devices\LPC54114\utilities; ..\..\..\..\components\libc\compilers\common\extension\fcntl\octal; ..\..\..\..\components\dfs\dfs_v1\filesystems\devfs; ..\..\..\..\components\drivers\spi; Libraries\devices\LPC54114\drivers; ..\..\..\..\components\libc\posix\io\poll; ..\..\..\..\components\libc\posix\io\epoll; Libraries\devices\LPC54114; ..\..\..\..\components\dfs\dfs_v1\include; ..\..\..\..\libcpu\arm\cortex-m4; drivers; .; ..\..\..\..\components\dfs\dfs_v1\filesystems\elmfat; ..\..\..\..\components\drivers\include; Libraries\CMSIS\Include; applications; ..\..\..\..\components\drivers\spi\sfud\inc; ..\..\..\..\components\libc\posix\io\eventfd; ..\..\..\..\include; ..\..\..\..\components\dfs\dfs_v1\filesystems\romfs; ..\..\..\..\components\libc\compilers\common\include; ..\..\..\..\components\libc\posix\ipc; ..\..\..\..\libcpu\arm\common; ..\..\..\..\components\finsh
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: drivers\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; _DLIB_FILE_DESCRIPTOR; __RTTHREAD__; SDK_DEBUGCONSOLE=0; CORE_M4; CPU_LPC54114; CPU_LPC54114J256BD64_cm4=1; __RT_IPC_SOURCE__; __RT_KERNEL_SOURCE__
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: mnt.c main.c
  group Compiler
    ../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../../components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
  group DeviceDrivers
    ../../../../components/drivers/core/: device.c
    ../../../../components/drivers/i2c/: i2c-bit-ops.c i2c_core.c i2c_dev.c
    ../../../../components/drivers/ipc/: completion.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../components/drivers/pin/: pin.c
    ../../../../components/drivers/serial/: serial.c
    ../../../../components/drivers/spi/sfud/src/: sfud.c
    ../../../../components/drivers/spi/: spi_core.c spi_dev.c spi_flash_sfud.c spi_msd.c
  group Drivers
    drivers/: drv_sdcard.c drv_gpio.c drv_uart.c drv_spi.c clock_config.c drv_romfs.c drv_i2c.c drv_spi_flash.c board.c
  group Filesystem
    ../../../../components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    ../../../../components/dfs/dfs_v1/filesystems/elmfat/: dfs_elm.c ff.c ffunicode.c
    ../../../../components/dfs/dfs_v1/filesystems/romfs/: dfs_romfs.c
    ../../../../components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    ../../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c msh_file.c
  group Kernel
    ../../../../src/: clock.c components.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
    ../../../../src/klibc/: kstdio.c kstring.c
  group libcpu
    ../../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../../libcpu/arm/cortex-m4/: context_iar.S cpuport.c
  group Libraries
    Libraries/devices/LPC54114/drivers/: fsl_adc.c fsl_clock.c fsl_common.c fsl_crc.c fsl_ctimer.c fsl_dma.c fsl_dmic.c fsl_dmic_dma.c fsl_flashiap.c fsl_flexcomm.c fsl_fmeas.c fsl_gint.c fsl_gpio.c fsl_i2c.c fsl_i2c_dma.c fsl_i2s.c fsl_i2s_dma.c fsl_inputmux.c fsl_mrt.c fsl_pint.c fsl_power.c fsl_reset.c fsl_rtc.c fsl_sctimer.c fsl_spi.c fsl_spi_dma.c fsl_usart.c fsl_usart_dma.c fsl_utick.c fsl_wwdt.c
    Libraries/devices/LPC54114/iar/: startup_LPC54114_cm4.s
    Libraries/devices/LPC54114/: system_LPC54114_cm4.c
