# IAR project project.ewp, settings and files
configuration rtthread (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1021xxx5A NXP MIMXRT1021xxx5A
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; _DLIB_FILE_DESCRIPTOR; CPU_MIMXRT1021DAG5A; ENDIANNESS; STD=C99; SKIP_SYSCLK_INIT; EVK_MCIMXRM; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; __RTTHREAD__
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ..\..\..\components\dfs\filesystems\devfs; ..\..\..\components\finsh; board\MCUX_Config; ..\..\..\components\drivers\include; ..\..\..\components\libc\compilers\common\extension; ..\libraries\MIMXRT1020\CMSIS\Include; ..\..\..\components\libc\compilers\common; ..\..\..\components\drivers\usb\usbdevice; ..\..\..\components\libc\posix\ipc; ..\..\..\components\dfs\include; ..\..\..\components\libc\posix\io\stdio; ..\libraries\drivers; .; xip; board; ..\..\..\components\drivers\spi; ..\..\..\components\libc\compilers\common\extension\fcntl\octal; board\ports; ..\libraries\MIMXRT1020\MIMXRT1021; ..\libraries\MIMXRT1020\MIMXRT1021\drivers; applications; ..\..\..\components\dfs\filesystems\elmfat; ..\..\..\components\libc\posix\io\poll; ..\libraries\peripherals; ..\..\..\include; ..\..\..\libcpu\arm\common; ..\..\..\libcpu\arm\cortex-m7
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: template.srec
  ILINK.IlinkOutputFile: rtthread.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Applications
    applications/: main.c
  group Compiler
    ../../../components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
    ../../../components/libc/compilers/common/: stdlib.c time.c
  group CPU
    ../../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m7/: context_iar.S cpu_cache.c cpuport.c
  group DeviceDrivers
    ../../../components/drivers/misc/: adc.c pin.c rt_drv_pwm.c
    ../../../components/drivers/sdio/: block_dev.c mmc.c mmcsd_core.c sd.c sdio.c
    ../../../components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/cputime/: cputime.c cputime_cortexm.c
    ../../../components/drivers/i2c/: i2c-bit-ops.c i2c_core.c i2c_dev.c
    ../../../components/drivers/spi/: qspi_core.c spi_core.c spi_dev.c
    ../../../components/drivers/rtc/: rtc.c
    ../../../components/drivers/serial/: serial.c
  group Drivers
    board/: board.c
    board/MCUX_Config/: clock_config.c pin_mux.c
    ../libraries/drivers/: drv_gpio.c drv_i2c.c drv_spi.c drv_uart.c
  group Filesystem
    ../../../components/dfs/filesystems/devfs/: devfs.c
    ../../../components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
    ../../../components/dfs/filesystems/elmfat/: dfs_elm.c ff.c ffunicode.c
  group Finsh
    ../../../components/finsh/: cmd.c msh.c msh_file.c shell.c
  group Kernel
    ../../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group Libraries
    ../libraries/MIMXRT1020/MIMXRT1021/drivers/: fsl_cache.c fsl_clock.c fsl_common.c fsl_dmamux.c fsl_edma.c fsl_gpio.c fsl_lpi2c.c fsl_lpspi.c fsl_lpspi_edma.c fsl_lpuart.c fsl_lpuart_edma.c fsl_usdhc.c
    ../libraries/MIMXRT1020/MIMXRT1021/iar/: startup_MIMXRT1021.s
    ../libraries/MIMXRT1020/MIMXRT1021/: system_MIMXRT1021.c
  group rt_usbd
    ../../../components/drivers/usb/usbdevice/class/: cdc_vcom.c mstorage.c
    ../../../components/drivers/usb/usbdevice/core/: usbdevice.c usbdevice_core.c
  group xip
    xip/: fsl_flexspi_nor_boot.c fsl_flexspi_nor_flash.c
