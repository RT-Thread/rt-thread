# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32G4FRMEL7 Nationstech
  pack: Nationstech.N32G4FR_DFP.1.0.4
  cpu: IRAM(0x20000000,0x24000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rtthread +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: RT_USING_LIBC, N32G4FR, __CLK_TCK=RT_TICK_PER_SECOND, USE_STDPERIPH_DRIVER, __STDC_LIMIT_MACROS, __RTTHREAD__, RT_USING_ARMLIBC
  c include: ..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\libraries\N32G4FR_Firmware_Library\n32g4fr_std_periph_driver\inc;..\..\..\components\drivers\include;..\..\..\components\finsh;..\..\..\components\libc\posix\io\epoll;..\libraries\n32_drivers;..\..\..\components\drivers\include;..\libraries\N32G4FR_Firmware_Library\CMSIS\core;..\..\..\components\drivers\include;..\..\..\components\libc\compilers\common\extension;..\..\..\libcpu\arm\common;..\libraries\N32G4FR_Firmware_Library\CMSIS;..\..\..\components\libc\posix\io\eventfd;board;..\..\..\components\drivers\phy;.;..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\components\drivers\include;..\..\..\components\drivers\spi;..\libraries\n32_drivers\config;..\..\..\libcpu\arm\cortex-m4;..\..\..\components\libc\compilers\common\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\libraries\N32G4FR_Firmware_Library\CMSIS\device;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\libc\posix\io\poll;..\..\..\components\libc\posix\ipc;..\..\..\components\drivers\smp_call;..\..\..\components\drivers\include;..\..\..\include;..\..\..\components\drivers\include;applications
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x24000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../components/drivers/can/: dev_can.c
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/hwtimer/: hwtimer.c
    ../../../components/drivers/i2c/: dev_i2c_bit_ops.c dev_i2c_core.c dev_i2c_dev.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/misc/: adc.c dac.c
    ../../../components/drivers/pin/: dev_pin.c
    ../../../components/drivers/rtc/: dev_rtc.c
    ../../../components/drivers/serial/: dev_serial.c
    ../../../components/drivers/spi/: dev_spi.c dev_spi_core.c
    ../../../components/drivers/watchdog/: dev_watchdog.c
  group Drivers
    ../libraries/N32G4FR_Firmware_Library/CMSIS/device/startup/: startup_n32g4fr.s
    board/: board.c
    ../libraries/n32_drivers/: drv_adc.c drv_can.c drv_dac.c drv_gpio.c drv_hwtimer.c drv_rtc.c drv_spi.c drv_usart.c drv_wdt.c
  group Finsh
    ../../../components/finsh/: shell.c msh_parse.c cmd.c msh.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    ../../../src/klibc/: kerrno.c rt_vsnprintf_tiny.c rt_vsscanf.c kstdio.c kstring.c
  group libcpu
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group libraries
    ../libraries/N32G4FR_Firmware_Library/n32g4fr_std_periph_driver/src/: n32g4fr_i2c.c n32g4fr_rtc.c n32g4fr_iwdg.c misc.c n32g4fr_rcc.c n32g4fr_can.c n32g4fr_exti.c n32g4fr_adc.c n32g4fr_spi.c n32g4fr_dac.c n32g4fr_gpio.c n32g4fr_tim.c n32g4fr_wwdg.c n32g4fr_usart.c
    ../libraries/N32G4FR_Firmware_Library/CMSIS/device/: system_n32g4fr.c
software components: CMSIS:CORE 5.4.0
