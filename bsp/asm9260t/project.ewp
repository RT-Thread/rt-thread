# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AT91SAM9260 Atmel AT91SAM9260
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 12
  General.FPU2: 0
  ICCARM.CCDefines: __RTTHREAD__; CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; __RT_IPC_SOURCE__; __RT_KERNEL_SOURCE__
  ICCARM.CCIncludePath2: applications; ..\..\libcpu\arm\common; ..\..\libcpu\arm\arm926; ..\..\components\drivers\include; ..\..\components\drivers\phy; ..\..\components\drivers\smp_call; drivers; platform; ..\..\components\finsh; .; ..\..\include; ..\..\components\libc\compilers\common\include; ..\..\components\libc\compilers\common\extension; ..\..\components\libc\compilers\common\extension\fcntl\octal; ..\..\components\libc\posix\io\epoll; ..\..\components\libc\posix\io\eventfd; ..\..\components\libc\posix\io\poll; ..\..\components\libc\posix\ipc; ..\..\components\net\utest
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: D:\GitHub\rt-thread\bsp\asm9260t\platform
  OBJCOPY.OOCOutputFile: rtthread.bin
  ILINK.IlinkOutputFile: rtthread.out
  ILINK.IlinkIcfFile: D:\GitHub\rt-thread\bsp\asm9260t\link_scripts\sdram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG; __RTTHREAD__; CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; __RT_IPC_SOURCE__; __RT_KERNEL_SOURCE__
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  group Applications
    applications/: application.c
  group CPU
    ../../libcpu/arm/arm926/: context_iar.S cpuport.c machine.c mmu.c stack.c start_iar.S trap.c
    ../../libcpu/arm/common/: div0.c showmem.c
  group DeviceDrivers
    ../../components/drivers/core/: device.c
    ../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../components/drivers/serial/: dev_serial.c
  group Drivers
    drivers/: board.c led.c usart.c
    platform/: gpio.c interrupt.c reset.c rt_low_level_init.c system_clock.c timer0.c uart.c
  group Finsh
    ../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler_comm.c scheduler_up.c slab.c thread.c timer.c
  group Libc
    ../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
    ../../src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
