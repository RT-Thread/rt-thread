<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
<batchBuild><batchDefinition><name>all</name><member><project>KsdkPlatformLib_K64F12</project><configuration>Debug</configuration></member><member><project>motor_demo_twrk64f120m</project><configuration>Debug</configuration></member><member><project>KsdkPlatformLib_K64F12</project><configuration>Release</configuration></member><member><project>motor_demo_twrk64f120m</project><configuration>Release</configuration></member></batchDefinition><batchDefinition><name>Debug</name><member><project>KsdkPlatformLib_K64F12</project><configuration>Debug</configuration></member><member><project>motor_demo_twrk64f120m</project><configuration>Debug</configuration></member></batchDefinition><batchDefinition><name>Release</name><member><project>KsdkPlatformLib_K64F12</project><configuration>Release</configuration></member><member><project>motor_demo_twrk64f120m</project><configuration>Release</configuration></member></batchDefinition></batchBuild>
<project><path>$WS_DIR$/../../../../lib/ksdk_platform_lib/KsdkPlatformLib/iar/KsdkPlatformLib_K64F12.ewp</path></project><project><path>$WS_DIR$/motor_demo_twrk64f120m.ewp</path></project></workspace>
