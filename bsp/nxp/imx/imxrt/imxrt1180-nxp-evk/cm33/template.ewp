# IAR project template.ewp, settings and files
configuration rtthread_ram (ARM)
  General.OGChipSelectEditMenu: MIMXRT1189xxx8_M33 NXP MIMXRT1189xxx8_M33
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 61
  General.FPU2: 6
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: template.srec
  ILINK.IlinkOutputFile: template.out
  ILINK.IlinkIcfFile: board\linker_scripts\MIMXRT1189xxxxx_cm33_ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration rtthread_ram_industry (ARM)
  as the first configuration, except:
  ILINK.IlinkIcfFile: board\linker_scripts\MIMXRT1189xxxxx_cm33_ram_industry.icf
configuration rtthread_flexspi_nor (ARM)
  as the first configuration, except:
  ILINK.IlinkIcfFile: board\linker_scripts\MIMXRT1189xxxxx_cm33_flexspi_nor.icf
configuration rtthread_flexspi_nor_hyperram (ARM)
  as the first configuration, except:
  ILINK.IlinkIcfFile: board\linker_scripts\MIMXRT1189xxxxx_cm33_flexspi_nor_hyperram.icf
