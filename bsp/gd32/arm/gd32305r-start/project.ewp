# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: GD32F305xC GD GD32F305xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: GD32F30X_CL; USE_STDPERIPH_DRIVER; __RTTHREAD__; CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; __RT_IPC_SOURCE__; __RT_KERNEL_SOURCE__
  ICCARM.CCIncludePath2: applications; ..\..\..\..\include; ..\..\..\..\components\drivers\include; ..\libraries\gd32_drivers; packages\gd32-arm-series-latest\GD32F30x\GD32F30x_standard_peripheral\Include; ..\..\..\..\components\drivers\smp_call; ..\..\..\..\libcpu\arm\common; ..\libraries\gd32_drivers\config; ..\..\..\..\components\libc\posix\io\eventfd; board; ..\..\..\..\components\libc\compilers\common\extension; .; ..\..\..\..\components\finsh; ..\..\..\..\components\libc\compilers\common\extension\fcntl\octal; ..\..\..\..\components\net\utest; ..\..\..\..\components\drivers\phy; packages\gd32-arm-cmsis-latest\GD32F30x; ..\..\..\..\components\libc\compilers\common\include; ..\..\..\..\components\libc\posix\ipc; ..\..\..\..\components\libc\posix\io\epoll; ..\..\..\..\libcpu\arm\cortex-m4; packages\gd32-arm-cmsis-latest\GD32F30x\GD\GD32F30x\Include; ..\..\..\..\components\libc\posix\io\poll
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: project.srec
  ILINK.IlinkOutputFile: rtthread.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; GD32F30X_CL; USE_STDPERIPH_DRIVER; __RTTHREAD__; CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; __RT_IPC_SOURCE__; __RT_KERNEL_SOURCE__
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: main.c
  group Compiler
    ../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../../components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
  group DeviceDrivers
    ../../../../components/drivers/core/: device.c
    ../../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../components/drivers/pin/: dev_pin.c
    ../../../../components/drivers/serial/: dev_serial.c
  group Drivers
    board/: board.c
    ../libraries/gd32_drivers/: drv_gpio.c drv_usart.c
  group Finsh
    ../../../../components/finsh/: cmd.c msh_parse.c shell.c msh.c
  group Kernel
    ../../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    ../../../../src/klibc/: rt_vsscanf.c rt_vsnprintf_tiny.c kstdio.c kerrno.c kstring.c
  group libcpu
    ../../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../../libcpu/arm/cortex-m4/: context_iar.S cpuport.c
  group Libraries
    packages/gd32-arm-cmsis-latest/GD32F30x/GD/GD32F30x/Source/IAR/: startup_gd32f30x_cl.s
    packages/gd32-arm-cmsis-latest/GD32F30x/GD/GD32F30x/Source/: system_gd32f30x.c
    packages/gd32-arm-series-latest/GD32F30x/GD32F30x_standard_peripheral/Source/: gd32f30x_exti.c gd32f30x_gpio.c gd32f30x_misc.c gd32f30x_rcu.c gd32f30x_usart.c
