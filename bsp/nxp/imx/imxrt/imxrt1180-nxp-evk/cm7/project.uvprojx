# Keil uVision project project.uvprojx, settings and files
target rtthread_ram (6220000::V6.22::ARMCLANG)
  device: MIMXRT1189CVM8C:cm7 NXP
  pack: NXP.MIMXRT1189_DFP.25.06.00
  cpu: IRAM(0x20484000,0x07c000) IRAM2(0x20500000,0x040000) IROM(0x00000000,0x028000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rtthread +hex
  c flags: Optim=5 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RT_USING_ARMLIBC, CPU_MIMXRT1189CVM8C_cm7, __CLK_TCK=RT_TICK_PER_SECOND, RT_USING_LIBC, __STDC_LIMIT_MACROS, NDEBUG, MIMXRT1189_cm7_SERIES, __RTTHREAD__, ARM_MATH_CM7
  c misc: -xc -std=gnu99 -mimplicit-float
  c include: ..\..\..\..\..\..\components\libc\compilers\common\extension\fcntl\octal;packages\nxp-imxrt-sdk-latest\MIMXRT1180\MIMXRT1189\drivers\cm7;..\..\..\..\..\..\components\libc\compilers\common\extension;board;packages\nxp-imxrt-sdk-latest\MIMXRT1180\MIMXRT1189;..\..\libraries\drivers;..\..\..\..\..\..\components\finsh;..\..\..\..\..\..\components\libc\posix\io\epoll;packages\nxp-imxrt-sdk-latest\MIMXRT1180\MIMXRT1189\drivers;..\..\..\..\..\..\components\drivers\smp_call;..\..\..\..\..\..\components\drivers\include;..\..\..\..\..\..\components\drivers\include;..\..\..\..\..\..\libcpu\arm\common;..\..\..\..\..\..\components\drivers\include;packages\nxp-imxrt-sdk-latest\MIMXRT1180\CMSIS\Core\m-profile;..\..\..\..\..\..\components\drivers\include;..\..\..\..\..\..\components\libc\posix\io\poll;board\MCUX_Config;board\ports;..\..\..\..\..\..\components\libc\compilers\common\include;..\..\..\..\..\..\components\libc\posix\io\eventfd;applications;..\..\..\..\..\..\components\net\utest;..\..\..\..\..\..\components\drivers\include;..\..\..\..\..\..\components\drivers\include;..\..\..\..\..\..\components\drivers\include;..\..\..\..\..\..\components\drivers\phy;..\..\..\..\..\..\include;..\..\..\..\..\..\components\libc\posix\ipc;packages\nxp-imxrt-sdk-latest\MIMXRT1180\MIMXRT1189\periph;packages\nxp-imxrt-sdk-latest\MIMXRT1180\CMSIS\Core\Include;.;..\..\..\..\..\..\libcpu\arm\cortex-m7
  asm misc: -x assembler-with-cpp
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x28000
  memory RVCT9: RAM 0x20484000 size 0x7c000
  memory RVCT10: RAM 0x20500000 size 0x40000
  scatter file: .\board\linker_scripts\MIMXRT1189xxxxx_cm7_ram.scf
  group Applications
    applications/: main.c
  group CPU
    ../../../../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../../../../libcpu/arm/cortex-m7/: context_rvds.S cpu_cache.c cpuport.c
  group DeviceDrivers
    ../../../../../../components/drivers/core/: device.c
    ../../../../../../components/drivers/i2c/: dev_i2c_bit_ops.c dev_i2c_core.c dev_i2c_dev.c
    ../../../../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../../../components/drivers/pin/: dev_pin.c
    ../../../../../../components/drivers/serial/: dev_serial_v2.c
  group Drivers
    board/MCUX_Config/: clock_config.c pin_mux.c
    board/: board.c
    ../../libraries/drivers/: drv_common.c drv_gpio.c drv_i2c.c drv_uart_v2.c
  group Finsh
    ../../../../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../../../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group Libc
    ../../../../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../../../../src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
  group Libraries
    packages/nxp-imxrt-sdk-latest/MIMXRT1180/MIMXRT1189/drivers/: fsl_common.c fsl_common_arm.c fsl_dcdc.c fsl_pmu.c fsl_clock.c fsl_ele_base_api.c fsl_s3mu.c fsl_trdc.c fsl_gpc.c fsl_memory.c fsl_soc_src.c fsl_edma.c fsl_edma_soc.c fsl_rgpio.c fsl_lpuart.c fsl_lpuart_edma.c fsl_lpi2c.c fsl_lpi2c_edma.c
    packages/nxp-imxrt-sdk-latest/MIMXRT1180/MIMXRT1189/: system_MIMXRT1189_cm7.c
    packages/nxp-imxrt-sdk-latest/MIMXRT1180/MIMXRT1189/drivers/cm7/: fsl_cache.c
    packages/nxp-imxrt-sdk-latest/MIMXRT1180/MIMXRT1189/arm/: startup_MIMXRT1189_cm7.s
target rtthread_hyperram (6220000::V6.22::ARMCLANG)
  device: MIMXRT1189CVM8C:cm7 NXP
  pack: NXP.MIMXRT1189_DFP.25.06.00
  cpu: as above
  output: rtthread +hex
  c flags: Optim=5 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: as above
  c misc: -xc -std=gnu99 -mimplicit-float
  c include: as above
  asm misc: -x assembler-with-cpp
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x28000
  memory RVCT9: RAM 0x20484000 size 0x7c000
  memory RVCT10: RAM 0x20500000 size 0x40000
  scatter file: .\board\linker_scripts\MIMXRT1189xxxxx_cm7_hyperram.scf
target rtthread_flexspi_nor (6220000::V6.22::ARMCLANG)
  device: MIMXRT1189CVM8C:cm7 NXP
  pack: NXP.MIMXRT1189_DFP.25.06.00
  cpu: as above
  output: rtthread +hex
  c flags: Optim=5 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: as above
  c misc: -xc -std=gnu99 -mimplicit-float
  c include: as above
  asm misc: -x assembler-with-cpp
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x28000
  memory RVCT9: RAM 0x20484000 size 0x7c000
  memory RVCT10: RAM 0x20500000 size 0x40000
  scatter file: .\board\linker_scripts\MIMXRT1189xxxxx_cm7_flexspi_nor.scf
target rtthread_flexspi_nor_hyperram (6220000::V6.22::ARMCLANG)
  device: MIMXRT1189CVM8C:cm7 NXP
  pack: NXP.MIMXRT1189_DFP.25.06.00
  cpu: as above
  output: rtthread +hex
  c flags: Optim=5 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: as above
  c misc: -xc -std=gnu99 -mimplicit-float
  c include: as above
  asm misc: -x assembler-with-cpp
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x28000
  memory RVCT9: RAM 0x20484000 size 0x7c000
  memory RVCT10: RAM 0x20500000 size 0x40000
  scatter file: .\board\linker_scripts\MIMXRT1189xxxxx_cm7_flexspi_nor_hyperram.scf
