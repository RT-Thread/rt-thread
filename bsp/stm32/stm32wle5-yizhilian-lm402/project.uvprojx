# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32WLE5JCIx STMicroelectronics
  pack: Keil.STM32WLxx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x20008000,0x00008000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: __RTTHREAD__, RT_USING_ARMLIBC, USE_HAL_DRIVER, RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND, __STDC_LIMIT_MACROS, STM32WLE5xx
  c include: ..\libraries\HAL_Drivers\drivers;..\..\..\libcpu\arm\common;board;..\..\..\components\libc\posix\io\eventfd;..\..\..\components\libc\compilers\common\include;applications;board\ports;..\..\..\components\drivers\include;..\libraries\HAL_Drivers\drivers\config;..\..\..\components\finsh;..\..\..\components\libc\posix\ipc;..\..\..\components\drivers\smp_call;..\..\..\components\drivers\include;..\..\..\components\libc\compilers\common\extension;..\libraries\HAL_Drivers;..\..\..\libcpu\arm\cortex-m4;..\..\..\components\libc\posix\io\poll;..\..\..\include;board\CubeMX_Config\Inc;..\..\..\components\drivers\include;..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\components\drivers\include;..\..\..\components\libc\posix\io\epoll;..\..\..\components\drivers\phy;..\..\..\components\drivers\include;..\libraries\STM32WLxx_HAL\STM32WLxx_HAL_Driver\Inc;..\libraries\STM32WLxx_HAL\CMSIS\Device\ST\STM32WLxx\Include;.;..\libraries\HAL_Drivers\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20008000 size 0x8000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/pin/: dev_pin.c
    ../../../components/drivers/serial/: dev_serial.c
  group Drivers
    ../libraries/HAL_Drivers/drivers/: drv_gpio.c drv_usart.c
    ../libraries/HAL_Drivers/: drv_common.c
    ../libraries/STM32WLxx_HAL/CMSIS/Device/ST/STM32WLxx/Source/Templates/arm/: startup_stm32wle5xx.s
    board/CubeMX_Config/Src/: stm32wlxx_hal_msp.c
    board/: board.c
  group Finsh
    ../../../components/finsh/: cmd.c msh.c msh_parse.c shell.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    ../../../src/klibc/: kstdio.c kerrno.c rt_vsnprintf_tiny.c rt_vsscanf.c kstring.c
  group libcpu
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group STM32_HAL
    ../libraries/STM32WLxx_HAL/STM32WLxx_HAL_Driver/Src/: stm32wlxx_hal_rcc.c stm32wlxx_hal_uart.c stm32wlxx_hal.c stm32wlxx_hal_cryp_ex.c stm32wlxx_hal_pwr_ex.c stm32wlxx_hal_crc.c stm32wlxx_hal_uart_ex.c stm32wlxx_hal_gpio.c stm32wlxx_hal_usart_ex.c stm32wlxx_hal_pwr.c stm32wlxx_hal_cryp.c stm32wlxx_hal_usart.c stm32wlxx_hal_comp.c stm32wlxx_hal_exti.c stm32wlxx_hal_crc_ex.c stm32wlxx_hal_rcc_ex.c stm32wlxx_hal_dma.c stm32wlxx_hal_rng.c stm32wlxx_hal_dma_ex.c stm32wlxx_hal_cortex.c
    ../libraries/STM32WLxx_HAL/CMSIS/Device/ST/STM32WLxx/Source/Templates/: system_stm32wlxx.c
