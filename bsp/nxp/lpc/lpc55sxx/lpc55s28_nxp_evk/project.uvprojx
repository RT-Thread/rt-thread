# Keil uVision project project.uvprojx, settings and files
target rtthread-lpc55s28 (6160000::V6.16::ARMCLANG)
  device: LPC55S28JBD100 NXP
  pack: NXP.LPC55S28_DFP.14.0.0
  cpu: IRAM(0x10000000,0x080000) IRAM2(0x20000000,0x030000) IROM(0x03000000,0x020000) IROM2(0x13000000,0x020000) XRAM(0x20040000,0x4000) XRAM2(0x30040000,0x4000) XRAM3(0x04000000,0x8000) XROM(0x00000000,0x080000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: rtthread
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=3
  c define: RT_USING_ARMLIBC, __STDC_LIMIT_MACROS, RT_USING_LIBC, __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND, DEBUG
  c misc: --target=arm-arm-none-eabi
  c include: ..\..\..\..\..\components\libc\compilers\common\include;.;..\..\..\..\..\components\drivers\smp_call;..\..\..\..\..\components\libc\compilers\common\extension;..\..\..\..\..\include;..\..\..\..\..\components\libc\posix\io\epoll;..\..\..\..\..\components\libc\posix\ipc;board\MCUX_Config\board;..\..\..\..\..\components\drivers\include;..\..\..\..\..\libcpu\arm\common;board;..\..\..\..\..\components\drivers\include;..\Libraries\CMSIS\Core\Include;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\..\..\components\libc\posix\io\poll;..\..\..\..\..\components\drivers\phy;..\Libraries\LPC55S28\LPC55S28;..\Libraries\LPC55S28\middleware\sdmmc\port;..\Libraries\drivers;applications;..\..\..\..\..\components\finsh;..\..\..\..\..\components\drivers\include;..\Libraries\LPC55S28\LPC55S28\drivers;..\..\..\..\..\components\libc\posix\io\eventfd;..\..\..\..\..\libcpu\arm\cortex-m33;..\Libraries\LPC55S28\components\codec;..\Libraries\LPC55S28\middleware\sdmmc\inc;..\..\..\..\..\components\drivers\include
  asm misc: -x assembler-with-cpp
  memory RVCT1: ROM 0x0 size 0x80000
  memory RVCT4: ROM 0x3000000 size 0x20000
  memory RVCT5: ROM 0x13000000 size 0x20000
  memory RVCT6: RAM 0x20040000 size 0x4000
  memory RVCT7: RAM 0x30040000 size 0x4000
  memory RVCT8: RAM 0x4000000 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x80000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: .\board\linker_scripts\LPC55S28_flash.scf
  group Applications
    applications/: main.c
  group Compiler
    ../../../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../../../components/drivers/core/: device.c
    ../../../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../../components/drivers/pin/: dev_pin.c
    ../../../../../components/drivers/serial/: dev_serial.c
  group Drivers
    board/MCUX_Config/board/: clock_config.c pin_mux.c
    board/: board.c
    ../Libraries/drivers/: drv_pin.c drv_uart.c
  group Finsh
    ../../../../../components/finsh/: cmd.c msh.c msh_parse.c shell.c
  group Kernel
    ../../../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    ../../../../../src/klibc/: kstring.c kerrno.c kstdio.c rt_vsscanf.c rt_vsnprintf_tiny.c
  group libcpu
    ../../../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../../../libcpu/arm/cortex-m33/: context_rvds.S cpuport.c syscall_rvds.S trustzone.c
  group Libraries
    ../Libraries/LPC55S28/LPC55S28/drivers/: fsl_dma.c fsl_usart_dma.c fsl_utick.c fsl_gpio.c fsl_i2s.c fsl_spi_dma.c fsl_plu.c fsl_usart.c fsl_common_arm.c fsl_cmp.c fsl_flexcomm.c fsl_rng.c fsl_wwdt.c fsl_iap.c fsl_pint.c fsl_ostimer.c fsl_sctimer.c fsl_puf.c fsl_i2c.c fsl_clock.c fsl_ctimer.c fsl_i2s_dma.c fsl_i2c_dma.c fsl_common.c fsl_anactrl.c fsl_hashcrypt.c fsl_lpadc.c fsl_reset.c fsl_gint.c fsl_sdif.c fsl_spi.c fsl_sysctl.c fsl_inputmux.c fsl_crc.c fsl_mrt.c fsl_casper.c fsl_power.c fsl_rtc.c
    ../Libraries/LPC55S28/LPC55S28/arm/: startup_LPC55S28.s
    ../Libraries/LPC55S28/LPC55S28/: system_LPC55S28.c
