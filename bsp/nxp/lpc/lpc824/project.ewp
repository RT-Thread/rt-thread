# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC824M201 NXP LPC824M201
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; _DLIB_FILE_DESCRIPTOR; __RTTHREAD__; CORE_M0PLUS; __RT_IPC_SOURCE__; __RT_KERNEL_SOURCE__
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\components\dfs\dfs_v1\include; drivers; ..\..\..\..\components\finsh; Libraries\common\board; ..\..\..\..\components\dfs\dfs_v1\filesystems\devfs; ..\..\..\..\components\drivers\include; Libraries\common\CMSIS; ..\..\..\..\components\libc\compilers\common\include; .; ..\..\..\..\components\libc\posix\ipc; ..\..\..\..\components\libc\posix\io\poll; Libraries\common\chip; ..\..\..\..\libcpu\arm\common; ..\..\..\..\libcpu\arm\cortex-m0; ..\..\..\..\components\drivers\smp; ..\..\..\..\include; ..\..\..\..\components\libc\compilers\common\extension; Libraries\peri_driver; ..\..\..\..\components\libc\posix\io\epoll; ..\..\..\..\components\libc\compilers\common\extension\fcntl\octal; applications; ..\..\..\..\components\libc\posix\io\eventfd
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: lpc824_rom.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; _DLIB_FILE_DESCRIPTOR; __RTTHREAD__; CORE_M0PLUS; __RT_IPC_SOURCE__; __RT_KERNEL_SOURCE__
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: application.c
  group Compiler
    ../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../../components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
  group DeviceDrivers
    ../../../../components/drivers/core/: device.c
    ../../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../components/drivers/pin/: dev_pin.c
    ../../../../components/drivers/serial/: dev_serial.c
  group Drivers
    drivers/: drv_usart.c board.c
  group Filesystem
    ../../../../components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    ../../../../components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    ../../../../components/finsh/: shell.c cmd.c msh_parse.c msh_file.c msh.c
  group Kernel
    ../../../../src/: clock.c components.c cpu_up.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
    ../../../../src/klibc/: kerrno.c kstdio.c kstring.c
  group libcpu
    ../../../../libcpu/arm/common/: div0.c showmem.c
    ../../../../libcpu/arm/cortex-m0/: context_iar.S cpuport.c
  group Libraries
    Libraries/peri_driver/sctimer/: sct_pwm_8xx.c sct_8xx.c
    Libraries/peri_driver/dma/: dma_8xx.c
    Libraries/common/board/: board_lpc.c
    Libraries/common/chip/: sysinit_8xx.c ioswm_8xx.c clock_8xx.c syscon_8xx.c
    Libraries/peri_driver/iap/: iap.c
    Libraries/peri_driver/wwdt/: wwdt_8xx.c
    Libraries/peri_driver/wkt/: wkt_8xx.c
    Libraries/peri_driver/adc/: adc_8xx.c
    Libraries/peri_driver/mrt/: stopwatch.c
    Libraries/peri_driver/i2c/: i2c_8xx.c
    Libraries/peri_driver/pmu/: pmu_8xx.c
    Libraries/peri_driver/crc/: crc_8xx.c
    Libraries/peri_driver/gpio/: gpio_8xx.c
    Libraries/peri_driver/uart/: uart_8xx.c ring_buffer.c
    Libraries/peri_driver/pinint/: pinint_8xx.c
    Libraries/peri_driver/acmp/: acmp_8xx.c
    Libraries/common/startup/: iar_startup_lpc82x.s
    Libraries/peri_driver/spi/: spi_8xx.c
