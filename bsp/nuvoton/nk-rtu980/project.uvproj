# Keil uVision project project.uvproj, settings and files
target rtthread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: Nuvoton_ARM9_Series Nuvoton
  cpu: IRAM(0x0-0x0) CLOCK(000000000) CPUTYPE(ARM926EJ-S)
  output: rtthread
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 v6Lang=1 v6LangP=1 wLevel=2
  c define: __CLK_TCK=RT_TICK_PER_SECOND, __RTTHREAD__, RT_USING_ARMLIBC, RT_USING_LIBC, __STDC_LIMIT_MACROS
  c misc: --c99
  c include: ..\..\..\components\drivers\phy;board;..\..\..\components\net\sal\include;..\..\..\libcpu\arm\arm926;..\..\..\components\drivers\hwcrypto;..\..\..\components\drivers\spi;..\libraries\nuc980\rtt_port;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\dfs\dfs_v1\filesystems\devfs;..\..\..\components\dfs\dfs_v1\include;..\..\..\components\net\lwip\lwip-2.1.2\src\include;..\..\..\components\net\sal\include\dfs_net;..\libraries\nu_packages\Demo;..\..\..\components\legacy\include;..\..\..\components\utilities\libadt\hashmap;..\..\..\components\libc\compilers\common\include;..\..\..\components\drivers\smp_call;..\..\..\components\fal\inc;..\..\..\include;..\..\..\components\utilities\libadt\bitmap;..\..\..\components\libc\posix\io\eventfd;..\..\..\components\legacy\usb\usbhost\core;..\..\..\components\net\netdev\include;..\..\..\components\drivers\spi\sfud\inc;..\..\..\components\utilities\libadt\avl;..\..\..\components\net\sal\include\socket;..\..\..\components\drivers\include;..\..\..\components\libc\compilers\common\extension;..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\components\net\sal\impl;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\utilities\libadt\ref;..\..\..\components\utilities\utest;..\..\..\components\libc\posix\io\poll;..\..\..\libcpu\arm\common;..\libraries\nuc980\UsbHostLib\inc;..\..\..\components\drivers\include;..\..\..\components\libc\posix\ipc;..\libraries\nu_packages\TPC;..\..\..\components\dfs\dfs_v1\filesystems\elmfat;.;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\libc\posix\io\epoll;..\libraries\nu_packages\NuUtils\inc;..\..\..\components\finsh;..\libraries\nuc980\Driver\Include;..\..\..\components\net\lwip\lwip-2.1.2\src\include\netif;..\..\..\components\net\sal\include\socket\sys_socket;..\..\..\components\utilities\libadt\uthash;..\..\..\components\legacy\usb\usbhost\include;..\..\..\components\drivers\include;..\..\..\components\legacy\usb\usbhost;..\..\..\components\drivers\include;applications;..\..\..\components\net\lwip\port;..\..\..\components\legacy\usb\usbdevice;..\..\..\components\legacy\usb\usbhost\class
  memory RVCT9: RAM 0x0 size 0x1
  scatter file: .\linking_scripts\nuc980.sct
  group Applications
    applications/: mnt.c main.c
  group board
    board/: nu_pin_init.c board_dev.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../components/drivers/can/: dev_can.c
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/cputime/: cputime.c cputimer.c
    ../../../components/drivers/hwcrypto/: hw_hash.c hw_rng.c hw_symmetric.c hwcrypto.c
    ../../../components/drivers/hwtimer/: hwtimer.c
    ../../../components/drivers/i2c/: dev_i2c_bit_ops.c dev_i2c_core.c dev_i2c_dev.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/misc/: adc.c
    ../../../components/drivers/pin/: dev_pin.c
    ../../../components/drivers/rtc/: dev_rtc.c dev_soft_rtc.c
    ../../../components/drivers/serial/: dev_serial.c
    ../../../components/drivers/spi/: dev_qspi_core.c dev_spi.c dev_spi_core.c dev_spi_flash_sfud.c
    ../../../components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    ../../../components/drivers/watchdog/: dev_watchdog.c
  group Drivers
    ../libraries/nuc980/rtt_port/: drv_etimer.c drv_scuart.c drv_sys.c drv_crypto.c drv_usbhost.c drv_softi2c.c drv_rtc.c drv_etimer_capture.c drv_pdma.c drv_ebi.c drv_wdt.c drv_i2c.c drv_can.c drv_spi.c drv_i2s.c drv_sdh.c drv_emac.c drv_qspi.c drv_pwm.c drv_common.c drv_uart.c drv_systick.c drv_gpio.c drv_adc.c drv_usbd.c
  group Fal
    ../../../components/fal/src/: fal_flash.c fal_rtt.c fal.c fal_partition.c
    ../../../components/fal/samples/porting/: fal_flash_sfud_port.c
  group Filesystem
    ../../../components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    ../../../components/dfs/dfs_v1/filesystems/elmfat/: dfs_elm.c ff.c ffunicode.c
    ../../../components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    ../../../components/finsh/: msh_parse.c msh_file.c cmd.c msh.c shell.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler_comm.c scheduler_up.c signal.c thread.c timer.c
  group klibc
    ../../../src/klibc/: kerrno.c rt_vsscanf.c kstring.c kstdio.c rt_vsnprintf_tiny.c
  group LIBADT
    ../../../components/utilities/libadt/avl/: avl.c
  group libcpu
    ../../../libcpu/arm/arm926/: context_rvds.S cpuport.c machine.c mmu.c stack.c start_rvds.S trap.c
    ../../../libcpu/arm/common/: div0.c showmem.c
  group Libraries
    ../libraries/nuc980/Driver/Source/: nu_cap.c nu_rtc.c nu_gpio.c nu_pdma.c nu_sdh.c nu_usbd.c nu_wdt.c nu_crypto.c nu_sys.c nu_i2s.c nu_i2c.c nu_ebi.c nu_spi.c nu_etimer.c nu_qspi.c nu_emac.c nu_uart.c nu_can.c nu_scuart.c nu_wwdt.c
  group lwIP
    ../../../components/net/lwip/lwip-2.1.2/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../components/net/lwip/lwip-2.1.2/src/apps/ping/: ping.c
    ../../../components/net/lwip/lwip-2.1.2/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../components/net/lwip/lwip-2.1.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../components/net/lwip/lwip-2.1.2/src/netif/: ethernet.c lowpan6.c
    ../../../components/net/lwip/port/: ethernetif.c sys_arch.c
  group nu_pkgs_demo
    ../libraries/nu_packages/Demo/: ccap_demo.c wormhole_demo.c atdev_utils.c usbd_cdc_vcom_echo.c usbd_hid_dance_mouse.c hwsem_counter.c smp_demo.c ccap_saver.c slcd_show_tick.c
  group nuc980_usbhostlib
    ../libraries/nuc980/UsbHostLib/src/: mem_alloc.c support.c usb_core.c ohci.c ehci.c ehci_iso.c
  group POSIX
    ../../../components/libc/posix/io/poll/: poll.c select.c
  group rt_usbd
    ../../../components/legacy/usb/usbdevice/class/: mstorage.c cdc_vcom.c
    ../../../components/legacy/usb/usbdevice/core/: usbdevice.c usbdevice_core.c
  group rt_usbh
    ../../../components/legacy/usb/usbhost/core/: driver.c hub.c usbhost_core.c usbhost.c
    ../../../components/legacy/usb/usbhost/class/: mass.c udisk.c
  group SAL
    ../../../components/net/netdev/src/: netdev.c netdev_ipaddr.c
    ../../../components/net/sal/dfs_net/: dfs_net.c
    ../../../components/net/sal/impl/: af_inet_lwip.c
    ../../../components/net/sal/socket/: net_netdb.c net_sockets.c
    ../../../components/net/sal/src/: sal_socket.c
  group UTest
    ../../../components/utilities/utest/: utest.c TC_uassert.c
