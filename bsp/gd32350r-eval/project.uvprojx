# Keil uVision project project.uvprojx, settings and files
target rt-thread_gd32f30x (ARM-ADS)
  device: GD32F350R8 GigaDevice
  pack: GigaDevice.GD32F3x0_DFP.2.0.0
  cpu: IRAM(0x20000000,0x04000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rtthread-gd32f3x0 +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=4 uC99=1 v6Lang=1 v6LangP=1
  c define: GD32F350, USE_STDPERIPH_DRIVER, __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND
  c include: applications;.;..\..\libcpu\arm\common;..\..\libcpu\arm\cortex-m4;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\drivers\include;drivers;..\..\components\finsh;.;..\..\include;..\..\components\libc\compilers\common;..\..\components\libc\compilers\common\nogcc;Libraries\CMSIS\GD\GD32F3x0\Include;Libraries\CMSIS;Libraries\GD32F3x0_standard_peripheral\Include;..\..\examples\utest\testcases\kernel
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Applications
    applications/: main.c
  group CPU
    ../../libcpu/arm/common/: showmem.c div0.c backtrace.c
    ../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../components/drivers/misc/: pin.c
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/src/: ringblk_buf.c workqueue.c pipe.c dataqueue.c completion.c ringbuffer.c waitqueue.c
  group Drivers
    drivers/: drv_gpio.c drv_usart.c board.c
  group Finsh
    ../../components/finsh/: shell.c msh.c cmd.c
  group Kernel
    ../../src/: components.c scheduler.c idle.c thread.c irq.c ipc.c device.c object.c mempool.c clock.c kservice.c timer.c mem.c
  group Libraries
    Libraries/GD32F3x0_standard_peripheral/Source/: gd32f3x0_dac.c gd32f3x0_dbg.c gd32f3x0_rcu.c gd32f3x0_i2c.c gd32f3x0_syscfg.c gd32f3x0_tsi.c gd32f3x0_cec.c gd32f3x0_wwdgt.c gd32f3x0_dma.c gd32f3x0_fmc.c gd32f3x0_pmu.c gd32f3x0_spi.c gd32f3x0_ctc.c gd32f3x0_adc.c gd32f3x0_usart.c gd32f3x0_gpio.c gd32f3x0_rtc.c gd32f3x0_exti.c gd32f3x0_misc.c gd32f3x0_timer.c gd32f3x0_fwdgt.c gd32f3x0_cmp.c gd32f3x0_crc.c
    Libraries/CMSIS/GD/GD32F3x0/Source/: system_gd32f3x0.c
    Libraries/CMSIS/GD/GD32F3x0/Source/ARM/: startup_gd32f3x0.s
software components: CMSIS:CORE 5.4.0
