# Keil uVision project project.uvprojx, settings and files
target rtthread (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: SWM320xE Synwit
  pack: Synwit.SWM32_DFP.1.16.6
  cpu: IRAM(0x20000000,0x20000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: RT_USING_ARM_LIBC, __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND
  c include: applications;.;..\..\libcpu\arm\common;..\..\libcpu\arm\cortex-m4;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\drivers\include;drivers;..\..\components\finsh;.;..\..\include;..\..\components\libc\compilers\armlibc;..\..\components\libc\compilers\common;..\..\components\libc\compilers\common\nogcc;libraries\CMSIS\CoreSupport;libraries\CMSIS\DeviceSupport;libraries\SWM320_StdPeriph_Driver;..\..\examples\utest\testcases\kernel
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\drivers\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group CPU
    ../../libcpu/arm/common/: backtrace.c showmem.c div0.c
    ../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../components/drivers/misc/: pin.c
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/src/: completion.c ringbuffer.c waitqueue.c workqueue.c ringblk_buf.c dataqueue.c pipe.c
  group Drivers
    drivers/: drv_gpio.c drv_uart.c board.c
  group Finsh
    ../../components/finsh/: shell.c msh.c cmd.c
  group Kernel
    ../../src/: mempool.c clock.c timer.c device.c object.c kservice.c thread.c memheap.c idle.c ipc.c irq.c components.c scheduler.c
  group libc
    ../../components/libc/compilers/armlibc/: libc.c mem_std.c syscalls.c
    ../../components/libc/compilers/common/: time.c stdlib.c
  group Libraries
    libraries/SWM320_StdPeriph_Driver/: SWM320_adc.c SWM320_port.c SWM320_crc.c SWM320_spi.c SWM320_uart.c SWM320_flash.c SWM320_can.c SWM320_sram.c SWM320_exti.c SWM320_sdram.c SWM320_i2c.c SWM320_dma.c SWM320_rtc.c SWM320_sdio.c SWM320_norflash.c SWM320_pwm.c SWM320_timr.c SWM320_wdt.c SWM320_gpio.c SWM320_lcd.c
    libraries/CMSIS/DeviceSupport/: system_SWM320.c
    libraries/CMSIS/DeviceSupport/startup/arm/: startup_SWM320.s
