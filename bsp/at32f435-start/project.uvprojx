# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: -AT32F435ZMT7 ArteryTek
  pack: ArteryTek.AT32F435_437_DFP.2.0.8
  cpu: IRAM(0x20000000,0x60000) IROM(0x08000000,0x3F0000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, AT32F435ZMT7, __RTTHREAD__, RT_USING_ARM_LIBC, __CLK_TCK=RT_TICK_PER_SECOND
  c include: applications;.;..\..\components\libc\compilers\common;..\..\components\libc\compilers\common\extension;..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\libcpu\arm\common;..\..\libcpu\arm\cortex-m4;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\drivers\spi;..\..\components\drivers\include;..\..\components\drivers\spi\sfud\inc;board;board\msp;libraries\rt_drivers;libraries\rt_drivers\config;..\..\components\finsh;.;..\..\include;libraries\AT32F435_437\cmsis\cm4\core_support;libraries\AT32F435_437\cmsis\cm4\device_support;libraries\AT32F435_437\drivers\inc;..\..\components\libc\posix\io\poll;..\..\components\libc\posix\io\stdio;..\..\components\libc\posix\ipc
  memory RVCT4: ROM 0x8000000 size 0x3f0000
  memory RVCT9: RAM 0x20000000 size 0x60000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group Compiler
    ../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../components/libc/compilers/common/: stdlib.c time.c
  group CPU
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../components/drivers/i2c/: i2c_core.c i2c_dev.c
    ../../components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../components/drivers/misc/: pin.c
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/spi/sfud/src/: sfud.c
    ../../components/drivers/spi/: spi_core.c spi_dev.c spi_flash_sfud.c
  group Drivers
    board/: board.c
    board/msp/: at32_msp.c system_at32f435_437.c
    libraries/AT32F435_437/cmsis/cm4/device_support/startup/mdk/: startup_at32f435_437.s
    libraries/rt_drivers/: drv_common.c drv_gpio.c drv_usart.c
  group Finsh
    ../../components/finsh/: shell.c msh.c cmd.c
  group Kernel
    ../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c thread.c timer.c
  group libraries
    libraries/AT32F435_437/drivers/src/: at32f435_437_gpio.c at32f435_437_exint.c at32f435_437_i2c.c at32f435_437_acc.c at32f435_437_dac.c at32f435_437_qspi.c at32f435_437_crc.c at32f435_437_dma.c at32f435_437_can.c at32f435_437_ertc.c at32f435_437_usb.c at32f435_437_spi.c at32f435_437_pwc.c at32f435_437_tmr.c at32f435_437_edma.c at32f435_437_emac.c at32f435_437_xmc.c at32f435_437_debug.c at32f435_437_dvp.c at32f435_437_misc.c at32f435_437_usart.c at32f435_437_wdt.c at32f435_437_flash.c at32f435_437_adc.c at32f435_437_wwdt.c at32f435_437_scfg.c at32f435_437_sdio.c at32f435_437_crm.c
    libraries/AT32F435_437/cmsis/cm4/device_support/: system_at32f435_437.c
