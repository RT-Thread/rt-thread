# IAR project project.ewp, settings and files
configuration rt-thread (ARM, debug)
  General.OGChipSelectEditMenu: STM32F767IG ST STM32F767IG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: STM32F767xx; __RTTHREAD__; USE_HAL_DRIVER
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\components\libc\compilers\common\nogcc; ..\libraries\STM32F7xx_HAL\CMSIS\Include; ..\..\..\components\finsh; ..\..\..\libcpu\arm\common; ..\..\..\libcpu\arm\cortex-m7; board\ports; ..\..\..\components\drivers\include; ..\..\..\examples\utest\testcases\kernel; .; applications; ..\libraries\HAL_Drivers\config; board; ..\..\..\components\libc\compilers\common; ..\libraries\STM32F7xx_HAL\STM32F7xx_HAL_Driver\Inc; board\CubeMX_Config\Inc; ..\..\..\include; ..\libraries\HAL_Drivers; ..\libraries\STM32F7xx_HAL\CMSIS\Device\ST\STM32F7xx\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../../rtthread.bin
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: main.c
  group CPU
    ../../../libcpu/arm/common/: backtrace.c showmem.c div0.c
    ../../../libcpu/arm/cortex-m7/: context_iar.S cpuport.c cpu_cache.c
  group DeviceDrivers
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/src/: ringbuffer.c workqueue.c waitqueue.c completion.c pipe.c dataqueue.c ringblk_buf.c
  group Drivers
    board/CubeMX_Config/Src/: stm32f7xx_hal_msp.c
    board/: board.c
    ../libraries/STM32F7xx_HAL/CMSIS/Device/ST/STM32F7xx/Source/Templates/iar/: startup_stm32f767xx.s
    ../libraries/HAL_Drivers/: drv_sdram.c drv_gpio.c drv_usart.c drv_lcd.c drv_common.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c cmd.c
  group Kernel
    ../../../src/: device.c kservice.c timer.c irq.c clock.c memheap.c mempool.c components.c ipc.c object.c idle.c thread.c scheduler.c
  group libc
    ../../../components/libc/compilers/common/: time.c
  group Libraries
    ../libraries/STM32F7xx_HAL/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_uart_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_sram.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_crc.c stm32f7xx_hal_usart.c stm32f7xx_hal_rcc.c stm32f7xx_hal_cec.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_cryp.c stm32f7xx_hal_gpio.c stm32f7xx_ll_dma2d.c stm32f7xx_hal_exti.c stm32f7xx_ll_fmc.c stm32f7xx_hal_cryp_ex.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_cortex.c stm32f7xx_hal_sdram.c stm32f7xx_hal_dma.c stm32f7xx_hal_uart.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rng.c stm32f7xx_hal_crc_ex.c
    ../libraries/STM32F7xx_HAL/CMSIS/Device/ST/STM32F7xx/Source/Templates/: system_stm32f7xx.c
