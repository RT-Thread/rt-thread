# Keil uVision project project.uvprojx, settings and files
target rtthread (6210000::V6.21::ARMCLANG)
  device: XMC7200D-E272K8384:Cortex-M7-0 Infineon
  pack: Infineon.CAT1C_DFP.1.0.0
  cpu: IRAM(0x28000000,0x100000) IROM(0x10000000,0x830000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: rtthread +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: COMPONENT_CAT1C, COMPONENT_MW_CORE_MAKE, COMPONENT_CAT1C8M, COMPONENT_CAT1, COMPONENT_MW_RETARGET_IO, COMPONENT_DebugCOMPONENT_GCC_ARM, COMPONENT_MW_CORE_LIB, CY_TARGET_BOARD=APP_KIT_XMC72_EVK, __RTTHREAD__, COMPONENT_MW_MTB_PDL_CAT1, COMPONENT_APP_KIT_XMC72_EVK, COMPONENT_CM7_0, __STDC_LIMIT_MACROS, __CLK_TCK=RT_TICK_PER_SECOND, XMC7200D_E272K8384, COMPONENT_SOFTFP, CY_SUPPORTS_DEVICE_VALIDATION, COMPONENT_MW_CAT1CM0P, RT_USING_ARMLIBC, CYBSP_WIFI_WL_REG_ON_GPIO_DRIVE_MODE=CYHAL_GPIO_DRIVE_STRONG, COMPONENT_MW_MTB_HAL_CAT1, RT_USING_LIBC, COMPONENT_XMC7x_CM0P_SLEEP, TARGET_APP_KIT_XMC72_EVK, DEBUG, COMPONENT_MW_RECIPE_MAKE_CAT1C, COMPONENT_MW_CMSIS, CY_USING_HAL, COMPONENT_CM7, CORE_NAME_CM7_0=1
  c include: ..\libraries\IFX_XMC_HAL\mtb-pdl-cat1\drivers\include;..\libraries\IFX_XMC_HAL\mtb-hal-cat1\include;applications;..\..\..\libcpu\arm\common;..\libraries\IFX_XMC_HAL\core-lib\include;libs\TARGET_APP_KIT_XMC72_EVK\config\GeneratedSource;..\..\..\components\libc\compilers\common\include;.;..\libraries\IFX_XMC_HAL\mtb-pdl-cat1\drivers\third_party\ethernet\include;..\..\..\components\drivers\include;..\..\..\components\libc\compilers\common\extension;libs\TARGET_APP_KIT_XMC72_EVK;..\libraries\IFX_XMC_HAL\mtb-pdl-cat1\devices\COMPONENT_CAT1C\include;..\libraries\IFX_XMC_HAL\mtb-hal-cat1\include_pvt;..\libraries\IFX_XMC_HAL\retarget-io;..\..\..\components\libc\posix\ipc;..\..\..\components\libc\posix\io\eventfd;..\..\..\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\libraries\IFX_XMC_HAL\mtb-hal-cat1\COMPONENT_CAT1C\include\pin_packages;..\..\..\components\libc\posix\io\epoll;..\libraries\IFX_XMC_HAL\cat1cm0p\COMPONENT_CAT1C;..\..\..\components\drivers\include;..\..\..\components\finsh;..\libraries\IFX_XMC_HAL\mtb-hal-cat1\COMPONENT_CAT1C\include\triggers;..\libraries\HAL_Drivers;board\ports;..\libraries\IFX_XMC_HAL\mtb-hal-cat1\COMPONENT_CAT1C\include;..\libraries\IFX_XMC_HAL\mtb-pdl-cat1\cmsis\Core\include;..\..\..\components\libc\posix\io\poll;board;..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\libraries\HAL_Drivers\config;..\libraries\IFX_XMC_HAL\mtb-pdl-cat1\drivers\COMPONENT_CAT1C\include;..\..\..\libcpu\arm\cortex-m7;..\libraries\IFX_XMC_HAL\mtb-pdl-cat1\devices\COMPONENT_CAT1C\include\ip
  memory RVCT4: ROM 0x10000000 size 0x830000
  memory RVCT9: RAM 0x28000000 size 0x100000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/pin/: pin.c
    ../../../components/drivers/serial/: serial.c
  group Drivers
    board/: board.c
    ../libraries/IFX_XMC_HAL/mtb-pdl-cat1/drivers/source/TOOLCHAIN_ARM/: cy_syslib_ext.s
    ../libraries/HAL_Drivers/: drv_common.c drv_gpio.c drv_uart.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
    ../../../src/klibc/: kstdio.c kstring.c
  group libcpu
    ../../../libcpu/arm/common/: div0.c showmem.c
    ../../../libcpu/arm/cortex-m7/: context_rvds.S cpu_cache.c cpuport.c
  group Libraries
    ../libraries/IFX_XMC_HAL/mtb-hal-cat1/source/: cyhal_keyscan.c cyhal_wdt.c cyhal_pwm.c cyhal_quaddec.c cyhal_opamp.c cyhal_scb_common.c cyhal_qspi.c cyhal_sdhc.c cyhal_ezi2c.c cyhal_syspm.c cyhal_interconnect.c cyhal_i2s.c cyhal_system.c cyhal_clock.c cyhal_spi.c cyhal_rtc.c cyhal_tcpwm_common.c cyhal_tdm.c cyhal_nvm.c cyhal_timer.c cyhal_adc_mic.c cyhal_gpio.c cyhal_hwmgr.c cyhal_comp.c cyhal_trng.c cyhal_comp_ctb.c cyhal_dma.c cyhal_uart.c cyhal_udb_sdio.c cyhal_dma_dmac.c cyhal_usb_dev.c cyhal_utils.c cyhal_ipc.c cyhal_dma_dw.c cyhal_utils_impl.c cyhal_adc_sar.c cyhal_comp_lp.c cyhal_crc.c cyhal_analog_common.c cyhal_crypto_common.c cyhal_i2c.c cyhal_irq_impl.c cyhal_audio_common.c cyhal_pdmpcm.c cyhal_dac.c cyhal_lptimer.c
    ../libraries/IFX_XMC_HAL/mtb-pdl-cat1/drivers/source/: cy_cryptolite_rsa.c cy_crypto_core_hw_v1.c cy_crypto_core_rsa.c cy_sysfault.c cy_cryptolite_ecdsa.c cy_sd_host.c cy_efuse.c cy_seglcd.c ppu_v1.c cy_cryptolite_hkdf.c cy_crypto_core_sha_v1.c cy_crypto_core_ecc_nist_p.c cy_sysint_v2.c cy_crypto.c cy_cryptolite_sha256.c cy_smartio.c cy_ipc_sema.c cy_smif_hb_flash.c cy_syspm_v3.c cy_tdm.c cy_cryptolite_aes_ccm.c cy_crypto_core_sha_v2.c cy_ctdac.c cy_cryptolite_aes.c cy_crypto_core_aes_v1.c cy_pra.c cy_dma.c cy_smif.c cy_syspm_ppu.c cy_cryptolite_trng.c cy_csd.c cy_flash_srom.c cy_ble_clk.c cy_cryptolite_utils.c cy_mcwdt_b.c cy_sar.c cy_smif_memslot.c cy_crypto_core_crc_v1.c cy_flash_v2.c cy_flash.c cy_sysclk.c cy_tcpwm_shiftreg.c cy_cryptolite_vu.c cy_crypto_core_hmac_v2.c cy_crypto_core_hw.c cy_smif_sfdp.c cy_tcpwm_quaddec.c cy_cryptolite_ecc_key_gen.c cy_lvd_ht.c cy_i2s.c cy_crypto_core_des_v2.c cy_ephy.c cy_crypto_core_mem_v1.c cy_sysanalog.c cy_syspm_pdcm.c cy_pdm_pcm.c cy_ipc_bt.c cy_wdt.c cy_crypto_core_ecc_domain_params.c cy_crypto_core_trng.c cy_crypto_core_vu.c cy_syspm_v2.c cy_ipc_drv.c cy_ipc_pipe.c cy_systick_v2.c cy_usbfs_dev_drv.c cy_crypto_core_ecc_key_gen.c cy_crypto_core_hmac_v1.c cy_lvd.c cy_usbfs_dev_drv_io.c cy_prot.c cy_mcwdt.c cy_systick.c cy_crypto_core_ecc_ecdsa.c cy_keyscan.c cy_sar2.c cy_syspm.c cy_syspm_btss.c cy_gpio.c cy_ctb.c cy_sysint.c cy_cryptolite_nist_p.c cy_crypto_core_prng_v2.c cy_dmac.c cy_syslib.c cy_crypto_core_cmac_v2.c cy_pra_cfg.c cy_evtgen.c cy_profile.c cy_cryptolite_hmac.c cy_ethif.c cy_scb_ezi2c.c cy_syspm_v4.c cy_adcmic.c cy_crypto_core_crc_v2.c cy_rtc.c cy_efuse_v3.c cy_scb_common.c cy_crypto_core_aes_v2.c cy_lin.c cy_crypto_core_prng_v1.c cy_tcpwm_counter.c cy_crypto_core_des_v1.c cy_pdm_pcm_v2.c cy_crypto_core_hkdf_v2.c cy_scb_i2c.c cy_wdt_b.c cy_tcpwm_pwm.c cy_crypto_core_cmac_v1.c cy_lpcomp.c cy_crypto_server.c cy_usbfs_dev_drv_io_dma.c cy_canfd.c cy_cryptolite_cmac.c cy_scb_spi.c cy_crypto_core_mem_v2.c cy_scb_uart.c cy_trigmux.c cy_sysclk_v2.c
    ../libraries/IFX_XMC_HAL/mtb-pdl-cat1/devices/COMPONENT_CAT1C/source/: cy_device.c
    ../libraries/IFX_XMC_HAL/mtb-pdl-cat1/drivers/third_party/ethernet/src/: edd.c edd_rx.c edd_tx.c
    ../libraries/IFX_XMC_HAL/mtb-hal-cat1/COMPONENT_CAT1C/source/triggers/: cyhal_triggers_xmc7200.c
    ../libraries/IFX_XMC_HAL/cat1cm0p/COMPONENT_CAT1C/COMPONENT_XMC7x_CM0P_SLEEP/: xmc7200_cm0p_sleep.c xmc7100_cm0p_sleep.c
    ../libraries/IFX_XMC_HAL/retarget-io/: cy_retarget_io.c
    ../libraries/IFX_XMC_HAL/mtb-hal-cat1/COMPONENT_CAT1C/source/pin_packages/: cyhal_xmc7200_272_bga.c
  group libs
    libs/TARGET_APP_KIT_XMC72_EVK/COMPONENT_CM7/: startup_cm7.c system_cm7.c
    libs/TARGET_APP_KIT_XMC72_EVK/config/GeneratedSource/: cycfg_clocks.c cycfg_system.c cycfg_peripherals.c cycfg.c cycfg_pins.c cycfg_qspi_memslot.c
    libs/TARGET_APP_KIT_XMC72_EVK/: cybsp.c
