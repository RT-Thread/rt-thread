# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC54114J256_M4 NXP LPC54114J256_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: CORE_M4; CPU_LPC54114; CPU_LPC54114J256BD64_cm4=1; SDK_DEBUGCONSOLE=0; RT_USING_DLIBC
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: Libraries\devices\LPC54114; Libraries\devices\LPC54114\utilities; Libraries\CMSIS\Include; ..\..\include; ..\..\components\libc\compilers\dlib; ..\..\components\finsh; drivers; ..\..\components\libc\compilers\common; .; applications; ..\..\libcpu\arm\cortex-m4; ..\..\libcpu\arm\common; Libraries\devices\LPC54114\drivers; ..\..\components\drivers\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: drivers\linker_scripts\LPC54114J256_cm4.icf
  ILINK.IlinkAdditionalLibs: Libraries\devices\LPC54114\iar\iar_lib_power.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; CORE_M4; CPU_LPC54114; CPU_LPC54114J256BD64_cm4=1; SDK_DEBUGCONSOLE=0; RT_USING_DLIBC
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: main.c mnt.c
  group Drivers
    drivers/: board.c clock_config.c drv_gpio.c drv_uart.c
  group CMSIS
    Libraries/devices/LPC54114/iar/: startup_LPC54114_cm4.s
    Libraries/devices/LPC54114/: system_LPC54114_cm4.c
  group Libraries
    Libraries/devices/LPC54114/drivers/: fsl_adc.c fsl_clock.c fsl_common.c fsl_crc.c fsl_ctimer.c fsl_dma.c fsl_dmic.c fsl_dmic_dma.c fsl_flashiap.c fsl_flexcomm.c fsl_fmeas.c fsl_gint.c fsl_gpio.c fsl_i2c.c fsl_i2c_dma.c fsl_i2s.c fsl_i2s_dma.c fsl_inputmux.c fsl_mrt.c fsl_pint.c fsl_power.c fsl_reset.c fsl_rtc.c fsl_sctimer.c fsl_spi.c fsl_spi_dma.c fsl_usart.c fsl_usart_dma.c fsl_utick.c fsl_wwdt.c
  group Kernel
    ../../src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group CORTEX-M4
    ../../libcpu/arm/cortex-m4/: cpuport.c context_iar.S
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
  group DeviceDrivers
    ../../components/drivers/misc/: pin.c
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
  group finsh
    ../../components/finsh/: shell.c symbol.c cmd.c msh.c msh_cmd.c msh_file.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_var.c finsh_vm.c finsh_token.c
  group libc
    ../../components/libc/compilers/common/: gmtime_r.c
  group dlib
    ../../components/libc/compilers/dlib/: environ.c libc.c rmtx.c stdio.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c time.c
