# Keil uVision project project.uvprojx, settings and files
target rtthread (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: MIMXRT1052CVL5B NXP
  pack: NXP.MIMXRT1052_DFP.13.0.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x00000000,0x020000) XRAM(0x20200000,0x040000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: __STDC_LIMIT_MACROS, RT_USING_ARMLIBC, SKIP_SYSCLK_INIT, RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND, FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1, __RTTHREAD__, CPU_MIMXRT1052CVL5B, XIP_EXTERNAL_FLASH=1, EVK_MCIMXRM
  c misc: --library_interface=armcc --library_type=standardlib --diag_suppress=66,1296,186
  c include: board\ports;..\..\..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\libraries\MIMXRT1050\MIMXRT1052\drivers;..\..\..\..\..\libcpu\arm\cortex-m7;..\libraries\MIMXRT1050\MIMXRT1052;applications;.;..\..\..\..\..\components\libc\compilers\common\include;board\MCUX_Config;board;..\..\..\..\..\components\finsh;..\..\..\..\..\components\drivers\include;..\..\..\..\..\libcpu\arm\common;..\..\..\..\..\components\drivers\include;..\..\..\..\..\include;..\..\..\..\..\components\libc\posix\io\eventfd;..\libraries\drivers;..\..\..\..\..\components\libc\posix\io\poll;..\libraries\MIMXRT1050\CMSIS\Include;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\libc\compilers\common\extension;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\libc\posix\io\epoll;..\..\..\..\..\components\libc\posix\ipc
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group Compiler
    ../../../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../../../components/drivers/core/: device.c
    ../../../../../components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../../components/drivers/pin/: pin.c
    ../../../../../components/drivers/serial/: serial.c
  group Drivers
    board/MCUX_Config/: clock_config.c pin_mux.c
    board/: board.c
    ../libraries/drivers/: drv_common.c drv_gpio.c drv_uart.c
  group Finsh
    ../../../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../../../../src/: clock.c components.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
    ../../../../../src/klibc/: kstdio.c kstring.c
  group libcpu
    ../../../../../libcpu/arm/common/: div0.c showmem.c
    ../../../../../libcpu/arm/cortex-m7/: context_rvds.S cpu_cache.c cpuport.c
  group Libraries
    ../libraries/MIMXRT1050/MIMXRT1052/: system_MIMXRT1052.c
    ../libraries/MIMXRT1050/MIMXRT1052/drivers/: generic_list.c fsl_gpio.c fsl_lpuart.c fsl_edma.c fsl_lpuart_edma.c fsl_clock.c fsl_dmamux.c fsl_xbarb.c fsl_cache.c fsl_common.c fsl_xbara.c fsl_os_abstraction_rtthread.c
    ../libraries/MIMXRT1050/MIMXRT1052/arm/: startup_MIMXRT1052.s
