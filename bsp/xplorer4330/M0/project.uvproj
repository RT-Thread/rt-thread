# Keil uVision project project.uvproj, settings and files
target LPC4330 SPIFI (ARM-ADS)
  device: LPC4330 CM0 NXP (founded by Philips)
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: rtthread_lpc43xx
  c flags: Optim=1
  c define: CORE_M0, __STDC_LIMIT_MACROS, USE_SPIFI, __RTTHREAD__, RT_USING_ARMLIBC, __CLK_TCK=RT_TICK_PER_SECOND, RT_USING_LIBC
  c include: ..\drivers;..\..\..\components\libc\compilers\common\include;..\..\..\components\drivers\include;..\..\..\include;..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\components\libc\compilers\common\extension;..\libraries\Device\NXP\LPC43xx\Include;..\applications;.;..\libraries\CMSIS\Include;..\..\..\components\libc\posix\io\epoll;..\..\..\components\drivers\smp_call;..\..\..\components\drivers\include;..\..\..\components\finsh;..\..\..\components\drivers\phy;..\..\..\components\libc\posix\io\poll;..\..\..\components\drivers\include;..\..\..\libcpu\arm\common;..\..\..\components\drivers\include;..\..\..\components\libc\posix\io\eventfd;..\..\..\components\libc\posix\ipc;..\..\..\libcpu\arm\cortex-m0;..\..\..\components\net\utest;..\..\..\components\drivers\include
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT1: ROM 0x14000000 size 0x400000
  memory RVCT9: RAM 0x10000000 size 0x10000
  group Applications
    ../applications/: application.c startup.c
  group CMSIS
    ../libraries/Device/NXP/LPC43xx/Source/Templates/: system_LPC43xx.c
    ../libraries/Device/NXP/LPC43xx/Source/Templates/ARM/: startup_LPC43xx_M0.s
  group CPU
    ../../../libcpu/arm/common/: div0.c showmem.c
    ../../../libcpu/arm/cortex-m0/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/serial/: dev_serial.c
  group Drivers
    ../drivers/: board.c drv_led.c drv_uart.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c msh_parse.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group Libc
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
target LPC4330 RAM (ARM-ADS)
  device: LPC4330 CM0 NXP (founded by Philips)
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: rtthread_lpc43xx
  c flags: Optim=1
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT9: RAM 0x10000000 size 0x10000
  group left out of the first target's files
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/serial/: dev_serial.c
    ../../../components/finsh/: msh.c msh_parse.c shell.c
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../libcpu/arm/common/: div0.c showmem.c
    ../../../libcpu/arm/cortex-m0/: context_rvds.S cpuport.c
    ../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
    ../../../src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
    ../applications/: application.c startup.c
    ../drivers/: board.c drv_led.c drv_uart.c
    ../libraries/Device/NXP/LPC43xx/Source/Templates/ARM/: startup_LPC43xx_M0.s
    ../libraries/Device/NXP/LPC43xx/Source/Templates/: system_LPC43xx.c
