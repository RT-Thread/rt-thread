# Keil uVision project libStdDriver.uvprojx, settings and files
target libstddriver-m2354 (6130001::V6.13.1::.\ARMCLANG)
  device: M2354ES Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.13
  cpu: IRAM(0x20000000,0x8000) IRAM2(0x30008000,0x10000) IROM(0x00000000,0x40000) IROM2(0x10040000,0x40000) CPUTYPE("Cortex-M23") TZ CLOCK(12000000) ESEL ELITTLE
  output: libstddriver_keil +hex (library)
  AfterMake: xcopy /y ".\build\keil5\@L.lib" "."
  c flags: OneElfS=1 v6Lang=5 v6LangP=3 wLevel=1
  c include: ..\inc;..\..\CMSIS\Include;..\..\Device\Nuvoton\M2354\Include;.
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x10040000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x30008000 size 0x10000
  scatter file: .\linking_scripts\m2354_flash.sct
  link misc: --map --first='startup_M2354.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group src
    ../src/: nu_acmp.c nu_bpwm.c nu_can.c nu_clk.c nu_crc.c nu_crypto.c nu_dac.c nu_dpm.c nu_eadc.c nu_ebi.c nu_ecap.c nu_epwm.c nu_ewdt.c nu_ewwdt.c nu_fmc.c nu_fvc.c nu_gpio.c nu_i2c.c nu_i2s.c nu_keystore.c nu_lcd.c nu_pdma.c nu_qei.c nu_qspi.c nu_rng.c nu_rtc.c nu_sc.c nu_scuart.c nu_sdh.c nu_spi.c nu_sys.c nu_tamper.c nu_timer.c nu_timer_pwm.c nu_uart.c nu_usbd.c nu_usci_i2c.c nu_usci_spi.c nu_usci_uart.c nu_wdt.c nu_wwdt.c nu_trng.c
