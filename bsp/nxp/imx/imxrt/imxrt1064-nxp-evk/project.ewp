# IAR project project.ewp, settings and files
configuration rtthread (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1052xxx5B NXP MIMXRT1052xxx5B
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; CPU_MIMXRT1064DVL6A; SKIP_SYSCLK_INIT; EVK_MCIMXRM; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=1; __RTTHREAD__; __RT_IPC_SOURCE__; __RT_KERNEL_SOURCE__
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ..\..\..\..\..\components\libc\posix\io\eventfd; ..\..\..\..\..\components\libc\compilers\common\extension; ..\..\..\..\..\components\libc\posix\io\epoll; ..\..\..\..\..\components\drivers\include; ..\..\..\..\..\libcpu\arm\cortex-m7; xip; applications; ..\..\..\..\..\components\libc\compilers\common\extension\fcntl\octal; ..\..\..\..\..\components\drivers\smp_call; ..\..\..\..\..\libcpu\arm\common; ..\..\..\..\..\include; ..\..\..\..\..\components\finsh; ..\..\..\..\..\components\libc\posix\io\poll; ..\libraries\drivers; .; ..\libraries\MIMXRT1064\CMSIS\Include; ..\libraries\MIMXRT1064\MIMXRT1064; ..\..\..\..\..\components\libc\compilers\common\include; ..\..\..\..\..\components\drivers\phy; ..\libraries\MIMXRT1064\MIMXRT1064\drivers; board\MCUX_Config; board; board\ports; ..\..\..\..\..\components\libc\posix\ipc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: template.srec
  ILINK.IlinkOutputFile: rtthread.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Applications
    applications/: main.c
  group Compiler
    ../../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../../../components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
  group DeviceDrivers
    ../../../../../components/drivers/core/: device.c
    ../../../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../../components/drivers/pin/: dev_pin.c
    ../../../../../components/drivers/serial/: dev_serial.c
  group Drivers
    board/MCUX_Config/: clock_config.c pin_mux.c
    board/: board.c
    ../libraries/drivers/: drv_common.c drv_gpio.c drv_uart.c
  group Finsh
    ../../../../../components/finsh/: msh.c cmd.c shell.c msh_parse.c
  group Kernel
    ../../../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    ../../../../../src/klibc/: kstring.c kstdio.c rt_vsscanf.c rt_vsnprintf_tiny.c kerrno.c
  group libcpu
    ../../../../../libcpu/arm/common/: div0.c showmem.c
    ../../../../../libcpu/arm/cortex-m7/: context_iar.S cpu_cache.c cpuport.c
  group Libraries
    ../libraries/MIMXRT1064/MIMXRT1064/: system_MIMXRT1064.c
    ../libraries/MIMXRT1064/MIMXRT1064/drivers/: fsl_gpio.c fsl_common.c fsl_cache.c fsl_lpuart.c fsl_clock.c
    ../libraries/MIMXRT1064/MIMXRT1064/iar/: startup_MIMXRT1064.s
  group xip
    xip/: evkmimxrt1064_sdram_ini_dcd.c fsl_flexspi_nor_boot.c evkmimxrt1064_flexspi_nor_config.c
