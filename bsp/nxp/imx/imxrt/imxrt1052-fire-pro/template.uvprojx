# Keil uVision project template.uvprojx, settings and files
target rtthread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MIMXRT1052:M7 NXP
  pack: NXP.iMXRT_DFP.1.0.3
  cpu: IRAM(0x20000000,0x00060000) IRAM2(0x00000000,0x00020000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c misc: --library_interface=armcc --library_type=standardlib --diag_suppress=66,1296,186
  memory RVCT9: RAM 0x20000000 size 0x60000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\board\linker_scripts\link.sct
  link misc: --diag_suppress=L6314
software components: CMSIS:CORE 5.0.2
