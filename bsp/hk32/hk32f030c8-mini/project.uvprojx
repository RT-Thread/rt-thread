# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: HK32F030C8Tx HK_MicroChip
  pack: HKMicroChip.HK32F0xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x00002800) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: HK32F030x8, __CLK_TCK=RT_TICK_PER_SECOND, __STDC_LIMIT_MACROS, USE_STDPERIPH_DRIVER, RT_USING_ARMLIBC, RT_USING_LIBC, __RTTHREAD__
  c include: board;..\libraries\rt_drivers;..\libraries\HK32F0xx_StdPeriph_Driver\CMSIS\Core;..\..\..\components\finsh;..\..\..\components\drivers\include;..\..\..\components\libc\posix\io\epoll;..\..\..\components\net\utest;..\..\..\components\drivers\smp_call;..\..\..\components\drivers\include;..\..\..\components\libc\compilers\common\extension;..\..\..\components\libc\posix\io\eventfd;..\..\..\components\libc\compilers\common\include;..\..\..\libcpu\arm\common;..\..\..\components\drivers\include;..\..\..\components\drivers\phy;..\..\..\libcpu\arm\cortex-m0;..\..\..\components\libc\posix\io\poll;..\..\..\components\libc\posix\ipc;applications;..\libraries\HK32F0xx_StdPeriph_Driver\CMSIS\HK32F0xx\Include;..\..\..\components\drivers\include;..\libraries\HK32F0xx_StdPeriph_Driver\inc;..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\components\drivers\include;board\msp;.;..\..\..\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2800
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group CPU
    ../../../libcpu/arm/common/: div0.c showmem.c
    ../../../libcpu/arm/cortex-m0/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/i2c/: dev_i2c_bit_ops.c dev_i2c_core.c dev_i2c_dev.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/pin/: dev_pin.c
    ../../../components/drivers/serial/: dev_serial.c
  group Drivers
    board/: board.c
    board/msp/: hk32_msp.c
    ../libraries/HK32F0xx_StdPeriph_Driver/CMSIS/HK32F0xx/Source/ARM/: startup_hk32f030x4x6x8.s
    ../libraries/HK32F0xx_StdPeriph_Driver/CMSIS/HK32F0xx/Source/: system_hk32f0xx.c
    ../libraries/rt_drivers/: drv_gpio.c drv_soft_i2c.c drv_usart.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group Libc
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
  group Libraries
    ../libraries/HK32F0xx_StdPeriph_Driver/src/: hk32f0xx_adc.c hk32f0xx_crc.c hk32f0xx_dbgmcu.c hk32f0xx_divsqrt.c hk32f0xx_dma.c hk32f0xx_exti.c hk32f0xx_flash.c hk32f0xx_gpio.c hk32f0xx_i2c.c hk32f0xx_iwdg.c hk32f0xx_misc.c hk32f0xx_pwr.c hk32f0xx_rcc.c hk32f0xx_rtc.c hk32f0xx_spi.c hk32f0xx_syscfg.c hk32f0xx_tim.c hk32f0xx_usart.c hk32f0xx_wwdg.c
