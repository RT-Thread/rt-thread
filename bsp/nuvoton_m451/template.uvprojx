# Keil uVision project template.uvprojx, settings and files
target template (ARM-ADS)
  device: M451VG6AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.0.5
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: template
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
