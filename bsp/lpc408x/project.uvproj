# Keil uVision project project.uvproj, settings and files
target rtthread (ARM-ADS)
  device: LPC4088 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: rtthread
  c flags: Optim=1
  c define: CORE_M4, __RTTHREAD__
  c include: applications;.;..\..\libcpu\arm\common;..\..\libcpu\arm\cortex-m4;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\drivers\include;drivers;..\..\components\dfs\include;..\..\components\dfs\filesystems\devfs;..\..\components\dfs\filesystems\elmfat;..\..\components\finsh;.;..\..\include;..\..\components\libc\compilers\common;Libraries\Device\NXP\LPC407x_8x_177x_8x\Include;Libraries\CMSIS\Include;Libraries\Drivers\include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group Applications
    applications/: main.c
  group CPU
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
  group DeviceDrivers
    ../../components/drivers/misc/: pin.c
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
  group Drivers
    drivers/: board.c drv_uart.c
  group Filesystem
    ../../components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
    ../../components/dfs/filesystems/devfs/: devfs.c
    ../../components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
  group finsh
    ../../components/finsh/: shell.c cmd.c msh.c msh_file.c
  group Kernel
    ../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group libc
    ../../components/libc/compilers/common/: time.c
  group Libraries
    Libraries/Device/NXP/LPC407x_8x_177x_8x/Source/Templates/: system_LPC407x_8x_177x_8x.c
    Libraries/Device/NXP/LPC407x_8x_177x_8x/Source/Templates/ARM/: startup_LPC407x_8x_177x_8x.s
    Libraries/Drivers/source/: lpc_adc.c lpc_bod.c lpc_can.c lpc_clkpwr.c lpc_crc.c lpc_dac.c lpc_eeprom.c lpc_emc.c lpc_exti.c lpc_gpdma.c lpc_gpio.c lpc_i2c.c lpc_i2s.c lpc_iap.c lpc_lcd.c lpc_mcpwm.c lpc_nvic.c lpc_pinsel.c lpc_pwm.c lpc_qei.c lpc_rtc.c lpc_ssp.c lpc_systick.c lpc_timer.c lpc_uart.c lpc_wwdt.c
