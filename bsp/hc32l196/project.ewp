# IAR project project.ewp, settings and files
configuration Debug (ARM)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: __RTTHREAD__; CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; __RT_IPC_SOURCE__; __RT_KERNEL_SOURCE__
  ICCARM.CCIncludePath2: applications; ..\..\libcpu\arm\common; ..\..\libcpu\arm\cortex-m0; ..\..\components\drivers\include; ..\..\components\drivers\phy; ..\..\components\drivers\smp_call; board; drivers; ..\..\components\finsh; libraries\CMSIS\Include; libraries\CMSIS\Device\HDSC\HC32L196\Include; libraries\HC32L196_StdPeriph_Driver\inc; .; ..\..\include; ..\..\components\libc\compilers\common\include; ..\..\components\libc\compilers\common\extension; ..\..\components\libc\compilers\common\extension\fcntl\octal; ..\..\components\libc\posix\io\epoll; ..\..\components\libc\posix\io\eventfd; ..\..\components\libc\posix\io\poll; ..\..\components\libc\posix\ipc; ..\..\components\net\utest
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: rtthread.bin
  ILINK.IlinkOutputFile: rtthread.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkConfigDefines: _LINK_FLASH_= 0; _HC32F448_256K_= 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  group Applications
    applications/: main.c
  group CPU
    ../../libcpu/arm/common/: div0.c showmem.c
    ../../libcpu/arm/cortex-m0/: context_iar.S cpuport.c
  group DeviceDrivers
    ../../components/drivers/core/: device.c
    ../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../components/drivers/pin/: dev_pin.c
    ../../components/drivers/serial/: dev_serial.c
  group Drivers
    board/: board.c board_config.c
    drivers/: drv_gpio.c drv_usart.c
  group Finsh
    ../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group HC32_StdPeriph
    libraries/CMSIS/Device/HDSC/HC32L196/Source/: system_hc32l19x.c interrupts_hc32l19x.c
    libraries/HC32L196_StdPeriph_Driver/src/: hc32l196_ddl.c hc32l196_gpio.c hc32l196_sysctrl.c hc32l196_flash.c hc32l196_uart.c
    libraries/CMSIS/Device/HDSC/HC32L196/Source/IAR/: startup_hc32l19x.s
  group Kernel
    ../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group Libc
    ../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
    ../../src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
