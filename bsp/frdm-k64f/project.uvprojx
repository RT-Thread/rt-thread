# Keil uVision project project.uvprojx, settings and files
target RT-Thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MK64FN1M0xxx12 NXP
  pack: NXP.MK64F12_DFP.10.0.4
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x1FFF0000,0x00010000) IROM(0x00000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rt-thread-k64f
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: CPU_MK64FN1M0VLL12
  c include: .;..\..\include;applications;.;board;device;device\MK64F12;..\..\libcpu\arm\common;..\..\libcpu\arm\cortex-m4;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\finsh;..\..\components\libc\compilers\common;..\..\components\net\lwip-2.0.2\src;..\..\components\net\lwip-2.0.2\src\include;..\..\components\net\lwip-2.0.2\src\include\ipv4;..\..\components\net\lwip-2.0.2\src\arch\include;..\..\components\net\lwip-2.0.2\src\include\netif;..\..\components\net\lwip-2.0.2\src\include\posix
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  group Kernel
    ../../src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group Applications
    applications/: application.c startup.c
  group Board
    board/: board.c clock_config.c drv_uart.c led.c drv_emac.c fsl_phy.c
  group Device
    device/MK64F12/: fsl_adc16.c fsl_clock.c fsl_cmp.c fsl_cmt.c fsl_common.c fsl_crc.c fsl_dac.c fsl_dmamux.c fsl_dspi.c fsl_dspi_edma.c fsl_edma.c fsl_enet.c fsl_ewm.c fsl_flash.c fsl_flexbus.c fsl_flexcan.c fsl_ftm.c fsl_gpio.c fsl_i2c.c fsl_i2c_edma.c fsl_llwu.c fsl_lptmr.c fsl_pdb.c fsl_pit.c fsl_pmc.c fsl_rcm.c fsl_rnga.c fsl_rtc.c fsl_sai.c fsl_sai_edma.c fsl_sdhc.c fsl_sim.c fsl_smc.c fsl_sysmpu.c fsl_uart.c fsl_uart_edma.c fsl_vref.c fsl_wdog.c
    device/: system_MK64F12.c
    device/TOOLCHAIN_ARM_STD/: startup_MK64F12.s
  group cpu
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
  group DeviceDrivers
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
  group finsh
    ../../components/finsh/: shell.c cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_var.c finsh_vm.c finsh_token.c
  group lwIP
    ../../components/net/lwip-2.0.2/src/arch/: sys_arch.c
    ../../components/net/lwip-2.0.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../components/net/lwip-2.0.2/src/core/: def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../components/net/lwip-2.0.2/src/netif/: ethernet.c ethernetif.c lowpan6.c
    ../../components/net/lwip-2.0.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
software components: CMSIS:CORE 5.0.1
