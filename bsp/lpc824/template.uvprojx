# Keil uVision project template.uvprojx, settings and files
target RT-Thread LPC82x (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: LPC824M201JHI33 NXP
  pack: Keil.LPC800_DFP.1.5.0
  cpu: IRAM(0x10000000,0x00002000) IROM(0x00000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: rtthread-lpc
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  scatter file: .\lpc824_rom.sct
software components: CMSIS:CORE 5.0.1
