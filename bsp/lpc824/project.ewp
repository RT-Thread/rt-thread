# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC824M201 NXP LPC824M201
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __RTTHREAD__; CORE_M0PLUS
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: applications; ..\..\components\libc\compilers\common\nogcc; ..\..\components\libc\posix\io\poll; .; Libraries\common\CMSIS; ..\..\include; ..\..\examples\utest\testcases\kernel; Libraries\common\board; ..\..\libcpu\arm\cortex-m0; ..\..\components\drivers\include; ..\..\components\finsh; Libraries\common\chip; ..\..\components\libc\compilers\common; Libraries\peri_driver; ..\..\libcpu\arm\common; drivers
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: lpc824_rom.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; __RTTHREAD__; CORE_M0PLUS
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: application.c startup.c
  group CPU
    ../../libcpu/arm/common/: showmem.c div0.c backtrace.c
    ../../libcpu/arm/cortex-m0/: context_iar.S cpuport.c
  group DeviceDrivers
    ../../components/drivers/src/: pipe.c workqueue.c waitqueue.c ringblk_buf.c completion.c dataqueue.c ringbuffer.c
  group Drivers
    drivers/: board.c usart.c
  group Finsh
    ../../components/finsh/: msh.c shell.c
  group Kernel
    ../../src/: object.c timer.c device.c components.c kservice.c ipc.c irq.c thread.c idle.c mem.c clock.c scheduler.c
  group Libraries
    Libraries/peri_driver/dma/: dma_8xx.c
    Libraries/peri_driver/adc/: adc_8xx.c
    Libraries/peri_driver/pinint/: pinint_8xx.c
    Libraries/peri_driver/crc/: crc_8xx.c
    Libraries/common/chip/: sysinit_8xx.c syscon_8xx.c ioswm_8xx.c clock_8xx.c
    Libraries/peri_driver/sctimer/: sct_pwm_8xx.c sct_8xx.c
    Libraries/peri_driver/i2c/: i2c_8xx.c
    Libraries/peri_driver/wwdt/: wwdt_8xx.c
    Libraries/common/startup/: iar_startup_lpc82x.s
    Libraries/peri_driver/pmu/: pmu_8xx.c
    Libraries/peri_driver/spi/: spi_8xx.c
    Libraries/peri_driver/wkt/: wkt_8xx.c
    Libraries/peri_driver/mrt/: stopwatch.c
    Libraries/peri_driver/gpio/: gpio_8xx.c
    Libraries/peri_driver/acmp/: acmp_8xx.c
    Libraries/peri_driver/uart/: ring_buffer.c uart_8xx.c
    Libraries/peri_driver/iap/: iap.c
    Libraries/common/board/: board_lpc.c
