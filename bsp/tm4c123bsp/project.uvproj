# Keil uVision project project.uvproj, settings and files
target rt-thread (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: RT_USING_LIBC, PART_TM4C123GH6PM, __RTTHREAD__, TARGET_IS_TM4C123_RB1, __CLK_TCK=RT_TICK_PER_SECOND, __STDC_LIMIT_MACROS, rvmdk, RT_USING_ARMLIBC
  c include: libraries\TivaWare_C_series\tm4c123_driverlib\driverlib\inc;..\..\components\drivers\include;..\..\components\drivers\include;board;..\..\components\drivers\include;..\..\libcpu\arm\cortex-m4;..\..\components\net\utest;..\..\components\libc\posix\ipc;libraries\TivaWare_C_series\tm4c123_driverlib\driverlib;..\..\components\libc\posix\io\poll;..\..\components\libc\compilers\common\include;.;..\..\components\drivers\include;..\..\components\drivers\include;applications;..\..\components\drivers\include;..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\components\drivers\smp_call;..\..\include;..\..\components\libc\posix\io\eventfd;libraries\Drivers;..\..\components\libc\compilers\common\extension;libraries\Drivers\config;libraries\TivaWare_C_series\tm4c123_driverlib;..\..\components\drivers\include;..\..\components\drivers\phy;..\..\components\drivers\include;..\..\components\libc\posix\io\epoll;..\..\components\drivers\spi;..\..\libcpu\arm\common;..\..\components\finsh
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group CPU
    ../../libcpu/arm/common/: div0.c showmem.c
    ../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../components/drivers/core/: device.c
    ../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../components/drivers/misc/: adc.c rt_drv_pwm.c
    ../../components/drivers/pin/: dev_pin.c
    ../../components/drivers/serial/: dev_serial.c
    ../../components/drivers/spi/: dev_spi.c dev_spi_core.c
  group Drivers
    board/: board.c tm4c123_config.c
    libraries/TivaWare_C_series/tm4c123_driverlib/startup/arm/: startup_rvmdk.S
    libraries/Drivers/: drv_adc.c drv_gpio.c drv_pwm.c drv_spi.c drv_uart.c
  group Finsh
    ../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group Libc
    ../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
  group Libraries
    libraries/TivaWare_C_series/tm4c123_driverlib/src/: sysctl.c systick.c interrupt.c fpu.c cpu.c gpio.c uart.c ssi.c pwm.c adc.c
