# Keil uVision project template.uvprojx, settings and files
target rt-thread (ARM-ADS)
  device: STM32L433CCTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.5.0
  cpu: IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00004000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x4000
  scatter file: .\board\linker_scripts\link.sct
