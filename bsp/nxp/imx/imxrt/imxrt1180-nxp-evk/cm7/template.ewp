# IAR project template.ewp, settings and files
configuration rtthread_ram (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1189xxx8_M7 NXP MIMXRT1189xxx8_M7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: template.srec
  ILINK.IlinkOutputFile: rtthread.out
  ILINK.IlinkIcfFile: board\linker_scripts\MIMXRT1189xxxxx_cm7_ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration rtthread_hyperram (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: board\linker_scripts\MIMXRT1189xxxxx_cm7_hyperram.icf
configuration rtthread_flexspi_nor (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: board\linker_scripts\MIMXRT1189xxxxx_cm7_flexspi_nor.icf
configuration rtthread_flexspi_nor_industry (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: board\linker_scripts\MIMXRT1189xxxxx_cm7_flexspi_nor_industry.icf
configuration rtthread_flexspi_nor_hyperram (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: board\linker_scripts\MIMXRT1189xxxxx_cm7_flexspi_nor_hyperram.icf
configuration rtthread_ram_industry (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkConfigDefines: __use_shmem__=1; __multicore__=1
  ILINK.IlinkIcfFile: board\linker_scripts\MIMXRT1189xxxxx_cm7_ram_industry.icf
