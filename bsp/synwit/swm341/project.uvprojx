# Keil uVision project project.uvprojx, settings and files
target rt-thread (6160000::V6.16::ARMCLANG)
  device: SWM341xE Synwit
  pack: Synwit.SWM32_DFP.1.17.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3
  c define: RT_USING_LIBC, RT_USING_ARMLIBC, __STDC_LIMIT_MACROS, __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND
  c include: libraries\CMSIS\CoreSupport;..\..\..\components\libc\compilers\common\extension\fcntl\octal;drivers;..\..\..\components\libc\compilers\common\extension;..\..\..\components\drivers\include;..\..\..\components\libc\posix\io\stdio;..\..\..\components\libc\posix\io\poll;..\..\..\components\libc\compilers\common\include;libraries\CMSIS\DeviceSupport;..\..\..\include;..\..\..\components\drivers\include;..\..\..\components\libc\posix\ipc;..\..\..\components\finsh;..\..\..\libcpu\arm\common;applications;..\..\..\components\drivers\include;.;..\..\..\libcpu\arm\cortex-m33;libraries\SWM341_StdPeriph_Driver
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\drivers\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdio.c cstdlib.c cstring.c ctime.c cwchar.c
  group CPU
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m33/: context_rvds.S cpuport.c syscall_rvds.S trustzone.c
  group DeviceDrivers
    ../../../components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/serial/: serial.c
  group Drivers
    drivers/: drv_gpio.c drv_uart.c board.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c object.c scheduler_up.c thread.c timer.c
  group Libraries
    libraries/SWM341_StdPeriph_Driver/: SWM341_dma2d.c SWM341_dac.c SWM341_pwm.c SWM341_timr.c SWM341_gpio.c SWM341_lcd.c SWM341_jpeg.c SWM341_sfc.c SWM341_can.c SWM341_uart.c SWM341_exti.c SWM341_usbd.c SWM341_spi.c SWM341_sdram.c SWM341_sleep.c SWM341_flash.c SWM341_div.c SWM341_port.c SWM341_dma.c SWM341_crc.c SWM341_i2c.c SWM341_sdio.c SWM341_usbh.c SWM341_cordic.c SWM341_rtc.c SWM341_adc.c SWM341_iofilt.c SWM341_qei.c SWM341_wdt.c
    libraries/CMSIS/DeviceSupport/: system_SWM341.c
    libraries/CMSIS/DeviceSupport/startup/arm/: startup_SWM341.s
