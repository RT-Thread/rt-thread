# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MCXC162 NXP MCXC162
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 58
  General.FPU2: 0
  ICCARM.CCDefines: CPU_MCXC162VFT; __RTTHREAD__; CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; __RT_IPC_SOURCE__; __RT_KERNEL_SOURCE__
  ICCARM.CCIncludePath2: applications; ..\..\..\..\..\libcpu\arm\common; ..\..\..\..\..\libcpu\arm\cortex-m23; ..\..\..\..\..\components\drivers\include; ..\..\..\..\..\components\drivers\smp_call; board; board\MCUX_Config\board; ..\libraries\drivers\mcxc162; ..\..\..\..\..\components\finsh; .; ..\..\..\..\..\include; ..\..\..\..\..\components\libc\compilers\common\include; ..\..\..\..\..\components\libc\compilers\common\extension; ..\..\..\..\..\components\libc\compilers\common\extension\fcntl\octal; ..\..\..\..\..\components\libc\posix\io\epoll; ..\..\..\..\..\components\libc\posix\io\eventfd; ..\..\..\..\..\components\libc\posix\io\poll; ..\..\..\..\..\components\libc\posix\ipc; packages\nxp-mcx-cmsis-latest\Core\Include; packages\nxp-mcx-series-latest\MCXC162; packages\nxp-mcx-series-latest\MCXC162\drivers; packages\nxp-mcx-series-latest\MCXC162\periph3; ..\..\..\..\..\components\net\utest
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: rtthread.out
  ILINK.IlinkIcfFile: packages\nxp-mcx-series-latest\MCXC162\iar\MCXC162_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MCXC162VFT; __RTTHREAD__; CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; __RT_IPC_SOURCE__; __RT_KERNEL_SOURCE__
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: main.c
  group CPU
    ../../../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../../../libcpu/arm/cortex-m23/: context_iar.S cpuport.c
  group DeviceDrivers
    ../../../../../components/drivers/core/: device.c
    ../../../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../../components/drivers/pin/: dev_pin.c
    ../../../../../components/drivers/serial/: dev_serial.c
  group Drivers
    board/MCUX_Config/board/: clock_config.c pin_mux.c
    board/: board.c
    ../libraries/drivers/mcxc162/: drv_pin.c drv_uart.c
  group Finsh
    ../../../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group Libc
    ../../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../../../components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
    ../../../../../src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
  group Libraries
    packages/nxp-mcx-series-latest/MCXC162/drivers/: fsl_clock.c fsl_common.c fsl_common_arm.c fsl_gpio.c fsl_lpuart.c fsl_reset.c fsl_spc.c
    packages/nxp-mcx-series-latest/MCXC162/: startup_MCXC162.c system_MCXC162.c
