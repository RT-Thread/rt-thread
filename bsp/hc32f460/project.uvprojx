# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: HC32F460PETB HDSC
  pack: HDSC.HC32F460.1.0.7
  cpu: IRAM(0x1FFF8000,0x2F000) IRAM2(0x200F0000,0x1000) IROM(0x00000000,0x80000) IROM2(0x03000C00,0x003FC) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: USE_DEVICE_DRIVER_LIB, __CLK_TCK=RT_TICK_PER_SECOND, HC32F460, __RTTHREAD__, __DEBUG, RT_USING_ARM_LIBC
  c misc: --diag_suppress=186,66
  c include: applications;.;..\..\libcpu\arm\common;..\..\libcpu\arm\cortex-m4;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\drivers\include;board;drivers;..\..\components\dfs\include;..\..\components\dfs\filesystems\devfs;..\..\components\finsh;Libraries\CMSIS\Include;Libraries\CMSIS\Device\HDSC\HC32F460\Include;Libraries\HC32F460_StdPeriph_Driver\inc;.;..\..\include;..\..\components\libc\compilers\armlibc;..\..\components\libc\compilers\common;..\..\components\libc\compilers\common\nogcc;..\..\examples\utest\testcases\kernel
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x3000c00 size 0x3fc
  memory RVCT9: RAM 0x1fff8000 size 0x2f000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group CPU
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../components/drivers/misc/: pin.c
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/src/: workqueue.c pipe.c completion.c dataqueue.c ringbuffer.c waitqueue.c ringblk_buf.c
  group Drivers
    board/: board_config.c board.c
    drivers/: drv_gpio.c drv_irq.c drv_usart.c
  group Filesystem
    ../../components/dfs/src/: dfs_posix.c dfs_poll.c dfs_file.c dfs.c dfs_fs.c dfs_select.c
    ../../components/dfs/filesystems/devfs/: devfs.c
  group Finsh
    ../../components/finsh/: shell.c msh.c msh_file.c cmd.c
  group HC32_StdPeriph
    Libraries/CMSIS/Device/HDSC/HC32F460/Source/: system_hc32f460.c
    Libraries/HC32F460_StdPeriph_Driver/src/: hc32f460_usart.c hc32f460_gpio.c hc32f460_clk.c hc32f460_efm.c hc32f460_sram.c hc32f460_utility.c hc32f460_exint_nmi_swi.c hc32f460_icg.c hc32f460_interrupts.c hc32f460_pwc.c
    Libraries/CMSIS/Device/HDSC/HC32F460/Source/ARM/: startup_hc32f460.s
  group Kernel
    ../../src/: mempool.c kservice.c components.c object.c timer.c ipc.c irq.c scheduler.c clock.c mem.c thread.c idle.c device.c
  group libc
    ../../components/libc/compilers/armlibc/: mem_std.c syscalls.c stdio.c libc.c
    ../../components/libc/compilers/common/: unistd.c delay.c stdlib.c time.c
