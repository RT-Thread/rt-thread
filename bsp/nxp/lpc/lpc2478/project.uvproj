# Keil uVision project project.uvproj, settings and files
target RT-Thread LPC2478 (ARM-ADS)
  device: LPC2478 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x4000FFFF) IRAM2(0x7FE00000-0x7FE03FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: rtthread-lpc
  c flags: Optim=1
  c define: RT_USING_LIBC, __STDC_LIMIT_MACROS, RT_USING_ARMLIBC, __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND
  c include: ..\..\..\..\components\libc\posix\ipc;..\..\..\..\components\drivers\include;..\..\..\..\components\drivers\smp_call;..\..\..\..\components\drivers\include;drivers;..\..\..\..\components\dfs\dfs_v1\filesystems\devfs;..\..\..\..\components\libc\compilers\common\include;..\..\..\..\components\drivers\include;..\..\..\..\components\drivers\include;..\..\..\..\components\libc\posix\io\poll;..\..\..\..\components\dfs\dfs_v1\include;.;..\..\..\..\components\drivers\phy;..\..\..\..\components\libc\compilers\common\extension;..\..\..\..\components\libc\posix\io\eventfd;..\..\..\..\components\net\utest;..\..\..\..\libcpu\arm\lpc24xx;..\..\..\..\components\libc\posix\io\epoll;..\..\..\..\include;..\..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\..\components\finsh;..\..\..\..\components\drivers\include;applications;..\..\..\..\libcpu\arm\common;..\..\..\..\components\drivers\include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x10000
  memory RVCT10: RAM 0x7fe00000 size 0x4000
  group Applications
    applications/: application.c startup.c
  group CPU
    ../../../../libcpu/arm/common/: div0.c showmem.c
    ../../../../libcpu/arm/lpc24xx/: context_rvds.S cpu.c interrupt.c stack.c start_rvds.S trap.c
  group DeviceDrivers
    ../../../../components/drivers/core/: device.c
    ../../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../components/drivers/pin/: dev_pin.c
    ../../../../components/drivers/serial/: dev_serial.c
  group Drivers
    drivers/: board.c serial.c
  group Filesystem
    ../../../../components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    ../../../../components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    ../../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c msh_file.c
  group Kernel
    ../../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group Libc
    ../../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../../src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
