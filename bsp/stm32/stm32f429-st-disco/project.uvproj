# Keil uVision project project.uvproj, settings and files
target rt-thread_stm32f4xx (ARM-ADS)
  device: STM32F429ZG STMicroelectronics
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: rtthread-stm32f4xx
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1
  c define: USE_HAL_DRIVER, __CLK_TCK=RT_TICK_PER_SECOND, RT_USING_ARM_LIBC, __RTTHREAD__, STM32F429xx
  c include: applications;..\..\..\libcpu\arm\common;..\..\..\libcpu\arm\cortex-m4;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\spi;..\..\..\components\drivers\include;..\..\..\components\drivers\include;board;board\CubeMX_Config\Inc;board\ports;..\libraries\HAL_Drivers;..\libraries\HAL_Drivers\config;..\..\..\components\dfs\include;..\..\..\components\dfs\filesystems\devfs;..\..\..\components\finsh;.;..\..\..\include;..\..\..\components\libc\compilers\armlibc;..\..\..\components\libc\compilers\common;..\..\..\components\libc\compilers\common\nogcc;..\libraries\STM32F4xx_HAL\STM32F4xx_HAL_Driver\Inc;..\libraries\STM32F4xx_HAL\CMSIS\Device\ST\STM32F4xx\Include;..\libraries\STM32F4xx_HAL\CMSIS\Include;..\..\..\examples\utest\testcases\kernel
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Applications
    applications/: lcd_init.c main.c
  group CPU
    ../../../libcpu/arm/common/: div0.c backtrace.c showmem.c
    ../../../libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
  group DeviceDrivers
    ../../../components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/spi/: spi_core.c spi_dev.c
    ../../../components/drivers/src/: ringbuffer.c pipe.c completion.c workqueue.c dataqueue.c waitqueue.c ringblk_buf.c
  group Drivers
    ../libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429xx.s
    board/CubeMX_Config/Src/: stm32f4xx_hal_msp.c
    board/ports/: ili9341.c
    board/: board.c
    ../libraries/HAL_Drivers/: drv_gpio.c drv_spi.c drv_sdram.c drv_lcd.c drv_usart.c drv_common.c
  group Filesystem
    ../../../components/dfs/src/: dfs_posix.c dfs_poll.c dfs_file.c dfs.c dfs_fs.c dfs_select.c
    ../../../components/dfs/filesystems/devfs/: devfs.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c msh_file.c cmd.c
  group Kernel
    ../../../src/: kservice.c idle.c thread.c irq.c device.c memheap.c clock.c scheduler.c object.c ipc.c signal.c mempool.c components.c timer.c
  group libc
    ../../../components/libc/compilers/armlibc/: stdio.c syscalls.c mem_std.c libc.c
    ../../../components/libc/compilers/common/: time.c stdlib.c unistd.c delay.c
  group Libraries
    ../libraries/STM32F4xx_HAL/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_qspi.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc_ex.c stm32f4xx_ll_dma2d.c stm32f4xx_hal_spi.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_usart.c stm32f4xx_hal_crc.c stm32f4xx_hal_sdram.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_rcc.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rng.c stm32f4xx_hal_cortex.c stm32f4xx_hal_cryp.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_ltdc.c stm32f4xx_hal.c stm32f4xx_hal_dsi.c stm32f4xx_hal_i2c.c stm32f4xx_hal_cec.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_ll_fmc.c stm32f4xx_hal_gpio.c
    ../libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
