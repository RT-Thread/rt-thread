# Keil uVision project project.uvprojx, settings and files
target rtthread (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: MM32L073PF MindMotion
  pack: MindMotion.MM32L0xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: __CLK_TCK=RT_TICK_PER_SECOND, __STDC_LIMIT_MACROS, __RTTHREAD__, RT_USING_ARMLIBC, RT_USING_LIBC, USE_STDPERIPH_DRIVER
  c include: ..\..\..\components\drivers\phy;packages\mm32l0xx-hal-driver-latest\Source;..\libraries\HAL_Drivers;..\..\..\components\net\utest;..\..\..\components\libc\compilers\common\include;..\..\..\components\drivers\include;board;..\..\..\components\finsh;..\..\..\include;applications;..\..\..\libcpu\arm\common;..\..\..\components\libc\posix\io\eventfd;packages\mm32l0xx-hal-driver-latest\Include;.;packages\mm32l0xx-cmsis-latest\CMSIS\CORE;..\..\..\components\drivers\include;..\libraries\HAL_Drivers\drivers;..\..\..\components\libc\compilers\common\extension;..\..\..\components\libc\posix\io\epoll;..\..\..\components\drivers\smp_call;..\..\..\components\drivers\include;..\..\..\components\libc\posix\io\poll;..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\components\drivers\include;..\libraries\HAL_Drivers\drivers\config;packages\mm32l0xx-cmsis-latest\CMSIS\CORE;..\..\..\libcpu\arm\cortex-m0;packages\mm32l0xx-hal-driver-latest\HAL_lib\inc;..\..\..\components\libc\posix\ipc;..\..\..\components\drivers\include
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group CPU
    ../../../libcpu/arm/common/: div0.c showmem.c
    ../../../libcpu/arm/cortex-m0/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/serial/: dev_serial.c
  group Drivers
    ../libraries/HAL_Drivers/drivers/: drv_uart.c
    board/: board.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group Libc
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
  group Libraries
    packages/mm32l0xx-hal-driver-latest/Source/: system_MM32L0xx.c
    packages/mm32l0xx-hal-driver-latest/HAL_lib/src/: HAL_adc.c HAL_bkp.c HAL_can.c HAL_comp.c HAL_dma.c HAL_exti.c HAL_flash.c HAL_gpio.c HAL_i2c.c HAL_iwdg.c HAL_misc.c HAL_pwr.c HAL_rcc.c HAL_spi.c HAL_syscfg.c HAL_tim.c HAL_uart.c HAL_wwdg.c
    packages/mm32l0xx-hal-driver-latest/Source/KEIL_StartAsm/: startup_MM32L0xx.s
