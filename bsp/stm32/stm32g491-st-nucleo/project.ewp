# IAR project project.ewp, settings and files
configuration rt-thread (ARM, debug)
  General.OGChipSelectEditMenu: STM32G491RE ST STM32G491RE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; STM32G491xx; __RTTHREAD__; USE_HAL_DRIVER; __RT_IPC_SOURCE__; __RT_KERNEL_SOURCE__
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\components\libc\compilers\common\extension; applications; ..\..\..\components\drivers\include; ..\libraries\HAL_Drivers\CMSIS\Include; ..\libraries\STM32G4xx_HAL\CMSIS\Device\ST\STM32G4xx\Include; ..\..\..\components\libc\compilers\common\extension\fcntl\octal; ..\libraries\STM32G4xx_HAL\STM32G4xx_HAL_Driver\Inc; .; ..\..\..\components\libc\posix\io\epoll; ..\..\..\components\drivers\phy; ..\..\..\components\libc\compilers\common\include; board\CubeMX_Config\Core\Inc; ..\..\..\components\libc\posix\io\poll; ..\..\..\components\libc\posix\ipc; ..\..\..\components\finsh; ..\libraries\HAL_Drivers\drivers\config; ..\libraries\HAL_Drivers; ..\..\..\libcpu\arm\common; board; ..\..\..\libcpu\arm\cortex-m4; ..\..\..\components\drivers\smp_call; ..\libraries\HAL_Drivers\drivers; ..\..\..\include; ..\..\..\components\libc\posix\io\eventfd
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../../rtthread.bin
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: main.c
  group Compiler
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/pin/: dev_pin.c
    ../../../components/drivers/serial/: dev_serial.c
  group Drivers
    ../libraries/HAL_Drivers/drivers/: drv_gpio.c drv_usart.c
    ../libraries/HAL_Drivers/: drv_common.c
    ../libraries/STM32G4xx_HAL/CMSIS/Device/ST/STM32G4xx/Source/Templates/iar/: startup_stm32g491xx.s
    board/CubeMX_Config/Core/Src/: stm32g4xx_hal_msp.c
    board/: board.c
  group Finsh
    ../../../components/finsh/: cmd.c msh_parse.c shell.c msh.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    ../../../src/klibc/: kstring.c rt_vsscanf.c kstdio.c rt_vsnprintf_tiny.c kerrno.c
  group libcpu
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m4/: context_iar.S cpuport.c
  group Libraries
    ../libraries/STM32G4xx_HAL/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_cortex.c stm32g4xx_hal_cryp.c stm32g4xx_hal_dma.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_gpio.c stm32g4xx_hal_usart_ex.c stm32g4xx_hal_crc.c stm32g4xx_hal_rcc.c stm32g4xx_hal_pwr.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_cryp_ex.c stm32g4xx_hal_rng.c stm32g4xx_hal_usart.c stm32g4xx_hal_uart.c stm32g4xx_hal.c stm32g4xx_hal_uart_ex.c stm32g4xx_hal_rcc_ex.c
    ../libraries/STM32G4xx_HAL/CMSIS/Device/ST/STM32G4xx/Source/Templates/: system_stm32g4xx.c
