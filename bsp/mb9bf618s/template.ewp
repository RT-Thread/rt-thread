# IAR project template.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MB9BF618S Fujitsu MB9BF618S
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: rtthread-fm3.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: template.out
