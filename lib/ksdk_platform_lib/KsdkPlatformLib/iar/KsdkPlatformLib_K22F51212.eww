<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/KsdkPlatformLib_K22F51212.ewp</path>
  </project>
</workspace>
