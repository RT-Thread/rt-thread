# Keil uVision project project.uvprojx, settings and files
target rtthread-m480 (ARM-ADS)
  device: M487JIDAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.5
  cpu: IRAM(0x20000000,0x28000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: rtthread +hex
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: RT_USING_ARM_LIBC, __RTTHREAD__
  c misc: --c99
  c include: applications;.;..\libraries\m480\CMSIS\Include;..\..\..\libcpu\arm\common;..\..\..\libcpu\arm\cortex-m4;..\..\..\components\drivers\audio;..\..\..\components\drivers\include;..\..\..\components\drivers\hwcrypto;.;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\spi;..\..\..\components\drivers\include;..\..\..\components\drivers\spi\sfud\inc;..\..\..\components\drivers\include;..\..\..\components\drivers\include;board;board\NuClockConfig;board\NuPinConfig;..\libraries\m480\Device\Nuvoton\M480\Include;..\libraries\m480\rtt_port;..\..\..\components\dfs\include;..\..\..\components\dfs\filesystems\devfs;..\..\..\components\dfs\filesystems\elmfat;..\..\..\components\finsh;.;..\..\..\include;..\..\..\components\libc\compilers\armlibc;..\..\..\components\libc\compilers\common;..\libraries\m480\StdDriver\inc;..\..\..\components\net\lwip-2.0.2\src;..\..\..\components\net\lwip-2.0.2\src\include;..\..\..\components\net\lwip-2.0.2\src\include\ipv4;..\..\..\components\net\lwip-2.0.2\src\arch\include;..\..\..\components\net\lwip-2.0.2\src\include\netif;..\libraries\m480\USBHostLib\inc;..\libraries\nu_packages\Demo;..\libraries\nu_packages\AudioCodec;..\libraries\nu_packages\NuUtils\inc;..\..\..\components\drivers\usb\usbdevice;..\..\..\components\drivers\usb\usbhost;..\..\..\components\drivers\usb\usbhost\class;..\..\..\components\drivers\usb\usbhost\core;..\..\..\components\drivers\usb\usbhost\include;..\..\..\components\drivers\include;..\..\..\components\net\netdev\include;..\..\..\components\net\sal_socket\include;..\..\..\components\net\sal_socket\include\socket;..\..\..\components\net\sal_socket\impl;..\..\..\components\net\sal_socket\include\socket\sys_socket;..\..\..\components\utilities\utest
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  scatter file: .\linking_scripts\m480_flash.sct
  group Applications
    applications/: main.c mnt.c
  group CPU
    ../../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
  group DeviceDrivers
    ../../../components/drivers/audio/: audio.c audio_pipe.c
    ../../../components/drivers/can/: can.c
    ../../../components/drivers/hwcrypto/: hwcrypto.c hw_symmetric.c hw_hash.c hw_rng.c hw_crc.c
    ../../../components/drivers/hwtimer/: hwtimer.c
    ../../../components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    ../../../components/drivers/misc/: pin.c adc.c rt_drv_pwm.c
    ../../../components/drivers/pm/: pm.c
    ../../../components/drivers/rtc/: rtc.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/spi/: spi_core.c spi_dev.c qspi_core.c spi_flash_sfud.c
    ../../../components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    ../../../components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/watchdog/: watchdog.c
  group Drivers
    board/NuClockConfig/: nutool_modclkcfg.c
    board/NuPinConfig/: nutool_pincfg.c
    board/: board.c board_dev.c
    ../libraries/m480/Device/Nuvoton/M480/Source/: system_M480.c
    ../libraries/m480/Device/Nuvoton/M480/Source/ARM/: startup_M480.s
    ../libraries/m480/rtt_port/: drv_bpwm.c drv_bpwm_capture.c drv_can.c drv_clk.c drv_crc.c drv_crypto.c drv_eadc.c drv_ebi.c drv_ecap.c drv_emac.c drv_epwm.c drv_epwm_capture.c drv_fmc.c drv_gpio.c drv_hsotg.c drv_hsusbd.c drv_i2c.c drv_i2s.c drv_pdma.c drv_qei.c drv_qspi.c drv_rtc.c drv_scuart.c drv_sdh.c drv_softi2c.c drv_spi.c drv_spii2s.c drv_timer.c drv_timer_capture.c drv_tpwm.c drv_trng.c drv_uart.c drv_ui2c.c drv_usbd.c drv_usbhost.c drv_uspi.c drv_uuart.c drv_wdt.c
  group Filesystem
    ../../../components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c poll.c select.c
    ../../../components/dfs/filesystems/devfs/: devfs.c
    ../../../components/dfs/filesystems/elmfat/: dfs_elm.c ff.c ffunicode.c
  group finsh
    ../../../components/finsh/: shell.c cmd.c msh.c msh_file.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_var.c finsh_vm.c finsh_token.c
  group Kernel
    ../../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group libc
    ../../../components/libc/compilers/armlibc/: libc.c mem_std.c stdio.c stubs.c
    ../../../components/libc/compilers/common/: time.c unistd.c
  group Libraries
    ../libraries/m480/StdDriver/src/: nu_acmp.c nu_bpwm.c nu_can.c nu_ccap.c nu_clk.c nu_crc.c nu_crypto.c nu_dac.c nu_eadc.c nu_ebi.c nu_ecap.c nu_emac.c nu_epwm.c nu_fmc.c nu_gpio.c nu_hsusbd.c nu_i2c.c nu_i2s.c nu_pdma.c nu_qei.c nu_qspi.c nu_rtc.c nu_sc.c nu_scuart.c nu_sdh.c nu_spi.c nu_spim.c nu_sys.c nu_timer.c nu_timer_pwm.c nu_trng.c nu_uart.c nu_usbd.c nu_usci_i2c.c nu_usci_spi.c nu_usci_uart.c nu_wdt.c nu_wwdt.c
  group lwIP
    ../../../components/net/lwip-2.0.2/src/arch/: sys_arch.c
    ../../../components/net/lwip-2.0.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../components/net/lwip-2.0.2/src/core/: def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../components/net/lwip-2.0.2/src/netif/: ethernet.c ethernetif.c lowpan6.c
    ../../../components/net/lwip-2.0.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../components/net/lwip-2.0.2/src/apps/ping/: ping.c
  group m480_usbhostlib
    ../libraries/m480/USBHostLib/src/: ehci.c ehci_iso.c mem_alloc.c ohci.c usb_core.c
  group nu_pkgs_demo
    ../libraries/nu_packages/Demo/: usbd_hid_dance_mouse.c slcd_show_tick.c usbd_cdc_vcom_echo.c
  group nu_pkgs_nau88l25
    ../libraries/nu_packages/AudioCodec/: audio_test.c acodec_nau88l25.c
  group rt_usbd
    ../../../components/drivers/usb/usbdevice/core/: usbdevice_core.c usbdevice.c
    ../../../components/drivers/usb/usbdevice/class/: hid.c
  group rt_usbh
    ../../../components/drivers/usb/usbhost/core/: usbhost_core.c driver.c usbhost.c hub.c
    ../../../components/drivers/usb/usbhost/class/: mass.c udisk.c
  group SAL
    ../../../components/net/netdev/src/: netdev.c netdev_ipaddr.c
    ../../../components/net/sal_socket/src/: sal_socket.c
    ../../../components/net/sal_socket/socket/: net_netdb.c
    ../../../components/net/sal_socket/impl/: af_inet_lwip.c
  group UTest
    ../../../components/utilities/utest/: utest.c
software components: CMSIS:CORE 5.1.2
