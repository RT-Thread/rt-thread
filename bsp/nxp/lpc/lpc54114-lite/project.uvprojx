# Keil uVision project project.uvprojx, settings and files
target rtthread-lpc54114 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC54114J256BD64:M4 NXP
  pack: Keil.LPC54000_DFP.2.6.0
  cpu: IRAM(0x20000000,0x00028000) IRAM2(0x04000000,0x00008000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rtthread-lpc54114
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: __STDC_LIMIT_MACROS, RT_USING_ARMLIBC, SDK_DEBUGCONSOLE=0, RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND, CPU_LPC54114, __RTTHREAD__, CPU_LPC54114J256BD64_cm4=1, CORE_M4
  c misc: --library_interface=armcc --library_type=standardlib --diag_suppress=66,1296,186
  c include: ..\..\..\..\libcpu\arm\cortex-m4;..\..\..\..\components\libc\compilers\common\extension\fcntl\octal;Libraries\devices\LPC54114\utilities;Libraries\devices\LPC54114;applications;..\..\..\..\components\libc\compilers\common\include;..\..\..\..\components\drivers\include;..\..\..\..\components\dfs\dfs_v1\filesystems\elmfat;..\..\..\..\libcpu\arm\common;Libraries\CMSIS\Include;..\..\..\..\components\finsh;..\..\..\..\components\libc\posix\io\epoll;..\..\..\..\components\dfs\dfs_v1\filesystems\devfs;Libraries\devices\LPC54114\drivers;..\..\..\..\components\drivers\include;..\..\..\..\include;..\..\..\..\components\libc\posix\io\eventfd;..\..\..\..\components\dfs\dfs_v1\filesystems\romfs;..\..\..\..\components\libc\posix\io\poll;..\..\..\..\components\drivers\include;..\..\..\..\components\drivers\include;..\..\..\..\components\drivers\spi;..\..\..\..\components\libc\compilers\common\extension;..\..\..\..\components\drivers\include;.;..\..\..\..\components\drivers\include;..\..\..\..\components\dfs\dfs_v1\include;..\..\..\..\components\libc\posix\ipc;drivers;..\..\..\..\components\drivers\spi\sfud\inc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x28000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: .\drivers\linker_scripts\link.scf
  group Applications
    applications/: mnt.c main.c
  group Compiler
    ../../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../../components/drivers/core/: device.c
    ../../../../components/drivers/i2c/: i2c-bit-ops.c i2c_core.c i2c_dev.c
    ../../../../components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../components/drivers/pin/: pin.c
    ../../../../components/drivers/serial/: serial.c
    ../../../../components/drivers/spi/sfud/src/: sfud.c
    ../../../../components/drivers/spi/: spi_core.c spi_dev.c spi_flash_sfud.c spi_msd.c
  group Drivers
    drivers/: drv_sdcard.c drv_gpio.c drv_uart.c drv_spi.c clock_config.c drv_romfs.c drv_i2c.c drv_spi_flash.c board.c
  group Filesystem
    ../../../../components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    ../../../../components/dfs/dfs_v1/filesystems/elmfat/: dfs_elm.c ff.c ffunicode.c
    ../../../../components/dfs/dfs_v1/filesystems/romfs/: dfs_romfs.c
    ../../../../components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    ../../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c msh_file.c
  group Kernel
    ../../../../src/: clock.c components.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
    ../../../../src/klibc/: kstdio.c kstring.c
  group libcpu
    ../../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group Libraries
    Libraries/devices/LPC54114/arm/: startup_LPC54114_cm4.s
    Libraries/devices/LPC54114/drivers/: fsl_adc.c fsl_clock.c fsl_common.c fsl_crc.c fsl_ctimer.c fsl_dma.c fsl_dmic.c fsl_dmic_dma.c fsl_flashiap.c fsl_flexcomm.c fsl_fmeas.c fsl_gint.c fsl_gpio.c fsl_i2c.c fsl_i2c_dma.c fsl_i2s.c fsl_i2s_dma.c fsl_inputmux.c fsl_mrt.c fsl_pint.c fsl_power.c fsl_reset.c fsl_rtc.c fsl_sctimer.c fsl_spi.c fsl_spi_dma.c fsl_usart.c fsl_usart_dma.c fsl_utick.c fsl_wwdt.c
    Libraries/devices/LPC54114/: system_LPC54114_cm4.c
