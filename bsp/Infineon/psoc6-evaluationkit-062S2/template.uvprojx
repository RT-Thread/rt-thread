# Keil uVision project template.uvprojx, settings and files
target rtthread (ARM-ADS)
  device: CY8C624ALQI-S2D42:Cortex-M4 Infineon
  pack: Infineon.PSoC6_DFP.1.3.0
  cpu: IRAM(0x08000000,0x00100000) IROM(0x10000000,0x00200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=3
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT9: RAM 0x8000000 size 0x100000
  scatter file: .\board\linker_scripts\link.sct
