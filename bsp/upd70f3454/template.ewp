# IAR project template.ewp, settings and files
configuration Debug (V850, debug)
  General.GMemoryModel: 0
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl85nn1.h
  General.GHeapSize: 4096
  General.GDeviceSelect: 70F3454 V850E - uPD70F3454
  ICCV850.CCDiagSuppress: Pa050
  ICCV850.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCV850.CCOptLevel: 1
  ICCV850.CCOptStrategy: 0
  ICCV850.IccLang: 0
  AV850.ADefines: CODE_MODEL_NORMAL; DATA_MODEL_TINY
  AV850.OAStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: lnk70f3454.xcl
  XLINK.XlinkStackSize: 1
configuration Release (V850)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICCV850.CCDefines: NDEBUG
  ICCV850.CCOptLevel: 3
  XLINK.XclFile: lnk0t.xcl
