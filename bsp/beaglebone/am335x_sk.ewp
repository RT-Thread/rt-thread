# IAR project am335x_sk.ewp, settings and files
configuration DDR Debug (ARM, debug)
  General.OGChipSelectEditMenu: am3359 TexasInstruments am3359
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 51
  General.FPU2: 0
  ICCARM.CCDefines: DDR_DEBUG
  ICCARM.CCIncludePath2: applications; drivers; ; ..\..\src; ..\..\include; ..\..\components\init; ..\..\libcpu\arm\am335x; ..\..\components\finsh; ..\..\components\drivers\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: am335x_sk.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: am335x_DDR.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group app
    applications/: application.c board.c startup.c
  group bsp
    ../../libcpu/arm/am335x/: context_iar.S cp15_iar.s cpu.c interrupt.c stack.c start_iar.s trap.c
  group components
    ../../components/drivers/src/: completion.c dataqueue.c
  group components/finsh
    ../../components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c msh.c msh_cmd.c shell.c symbol.c
  group drivers
    ../../components/drivers/serial/: serial.c
    drivers/: uart.c
  group kernel
    ../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c module.c object.c scheduler.c slab.c thread.c timer.c
