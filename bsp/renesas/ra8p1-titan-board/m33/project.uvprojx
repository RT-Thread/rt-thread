# Keil uVision project project.uvprojx, settings and files
target M33_Debug_CPU1 (6190000::V6.19::ARMCLANG)
  device: R7KA8P1KF:CPU1 Renesas
  pack: Renesas.RA_DFP.6.5.1
  cpu: CPUTYPE("Cortex-M33") DSP TZ FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: template +hex
  AfterMake: cmd /c ""$Prasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --gensmartbundle --compiler ARMv6 --devicefamily ra "$Pconfiguration.xml" "$L%L" 2> "$PObjects\rasc_stderr.out""
  c flags: v6Lang=3 v6LangP=6
  c define: _RENESAS_RA_, __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND, RT_USING_ARMLIBC, _RA_CORE=CPU1, RT_USING_LIBC, __STDC_LIMIT_MACROS, _RA_ORDINAL=2
  c include: ..\..\..\..\libcpu\arm\common;..\..\..\..\components\drivers\include;board;ra\fsp\inc\instances;..\..\..\..\components\libc\posix\io\epoll;..\..\..\..\components\drivers\include;..\..\libraries\HAL_Drivers;..\..\..\..\components\drivers\smp_call;.;ra\fsp\inc\api;..\..\..\..\components\drivers\include;..\..\..\..\libcpu\arm\cortex-m33;ra_cfg\fsp_cfg;..\..\..\..\components\finsh;ra_cfg\fsp_cfg\bsp;..\..\..\..\components\libc\posix\io\poll;ra\fsp\inc;..\..\..\..\include;..\..\..\..\components\drivers\include;ra_gen;..\..\libraries\HAL_Drivers\drivers\config;..\..\..\..\components\libc\compilers\common\include;..\..\..\..\components\drivers\include;..\..\..\..\components\drivers\phy;..\..\..\..\components\libc\posix\ipc;ra\arm\CMSIS_6\CMSIS\Core\Include;..\..\..\..\components\drivers\include;..\..\libraries\HAL_Drivers\drivers;..\..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\..\components\libc\posix\io\eventfd;..\..\..\..\components\net\utest;..\..\..\..\components\libc\compilers\common\extension
  asm include: .
  scatter file: .\script\fsp.scat
  link misc: --entry=Reset_Handler --no_startup
  group Applications
    src/: hal_entry.c
  group CPU
    ../../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../../libcpu/arm/cortex-m33/: context_rvds.S cpuport.c syscall_rvds.S trustzone.c
  group DeviceDrivers
    ../../../../components/drivers/core/: device.c
    ../../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../components/drivers/pin/: dev_pin.c
    ../../../../components/drivers/serial/: dev_serial_v2.c
  group Drivers
    ../../libraries/HAL_Drivers/drivers/: drv_gpio.c drv_usart_v2.c
    ../../libraries/HAL_Drivers/: drv_common.c
    board/: ra8_it.c
  group Finsh
    ../../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group Libc
    ../../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../../src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
  group RA
    ra/fsp/src/bsp/mcu/all/: bsp_clocks.c bsp_common.c bsp_delay.c bsp_group_irq.c bsp_guard.c bsp_io.c bsp_ipc.c bsp_irq.c bsp_macl.c bsp_ospi_b.c bsp_register_protection.c bsp_sbrk.c bsp_sdram.c bsp_security.c
    ra/fsp/src/bsp/mcu/ra8p1/: bsp_linker.c
    ra/fsp/src/bsp/cmsis/Device/RENESAS/Source/: system.c startup.c
    ra/fsp/src/r_ioport/: r_ioport.c
    ra/fsp/src/r_sci_b_uart/: r_sci_b_uart.c
  group RA_gen
    ra_gen/: common_data.c hal_data.c main.c pin_data.c vector_data.c
target M33_Download_CPU0 (6190000::V6.19::ARMCLANG)
  device: R7KA8P1KF:CPU0 Renesas
  pack: Renesas.RA_DFP.6.5.1
  cpu: CPUTYPE("Cortex-M85") DSP TZ MVE(FP) FPU3(DFPU) PACBTI CLOCK(12000000) ELITTLE
  output: template
  AfterMake: as above
  c flags: v6Lang=3 v6LangP=6
  scatter file: .\script\fsp.scat
  link misc: --entry=Reset_Handler --no_startup
software components: Flex Software:RA Configuration 1.0.0
