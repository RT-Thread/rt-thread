# Keil uVision project arm_graphic_equalizer_example.uvprojx, settings and files
target ARMCM0 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.0.0-Beta12
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(10000000) ELITTLE
  output: arm_graphic_equalizer_example
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: ARM_MATH_CM0
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Files
    ./: math_helper.c arm_graphic_equalizer_data.c arm_graphic_equalizer_example_q31.c
  group Documentation
    ./: Abstract.txt
target ARMCM3 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.0.0-Beta12
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(10000000) ELITTLE
  output: arm_graphic_equalizer_example
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: ARM_MATH_CM3
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
target ARMCM4_FP (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.0.0-Beta12
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: arm_graphic_equalizer_example
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: ARM_MATH_CM4 __FPU_PRESENT=1U
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
target ARMCM7_SP (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: ARMCM7_SP ARM
  pack: ARM.CMSIS.5.0.0-Beta12
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ESEL ELITTLE
  output: arm_graphic_equalizer_example
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: ARM_MATH_CM7 __FPU_PRESENT=1U
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
software components: CMSIS:CORE 3.40.0, CMSIS:DSP 1.4.2, Device:Startup 1.0.1, Device:Startup 1.0.1, Device:Startup 1.0.1, Device:Startup 1.0.1
