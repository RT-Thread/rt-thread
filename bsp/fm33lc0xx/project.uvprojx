# Keil uVision project project.uvprojx, settings and files
target RT_Thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: FM33LC04X FMSH
  pack: Keil.FM33LC0XX_DFP.3.0.1
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x6000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: rt-thread +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER, FM33LC0XX, __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND
  c include: applications;..\..\libcpu\arm\common;..\..\libcpu\arm\cortex-m0;..\..\components\drivers\include;..\..\components\drivers\include;board;libraries\HAL_Drivers;libraries\HAL_Drivers\config;..\..\components\finsh;libraries\FM33LC0xx_FL_Driver\CMSIS\Include;libraries\FM33LC0xx_FL_Driver\Inc;.;..\..\include;..\..\components\libc\compilers\common;..\..\components\libc\compilers\common\none-gcc;..\..\examples\utest\testcases\kernel
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x6000
  group Applications
    applications/: main.c
  group CPU
    ../../libcpu/arm/common/: div0.c showmem.c backtrace.c
    ../../libcpu/arm/cortex-m0/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/src/: ringbuffer.c ringblk_buf.c waitqueue.c workqueue.c completion.c pipe.c dataqueue.c
  group Drivers
    libraries/FM/FM33xx/Source/Templates/ARM/: startup_fm33lc0xx.s
    board/: board.c
    libraries/HAL_Drivers/: drv_usart.c drv_common.c
  group finsh
    ../../components/finsh/: finsh_node.c finsh_parser.c cmd.c msh.c finsh_vm.c shell.c finsh_var.c finsh_compiler.c finsh_heap.c finsh_ops.c finsh_error.c finsh_token.c finsh_init.c
  group FM33LC0xx_FL_Driver
    libraries/FM33LC0xx_FL_Driver/Src/: fm33lc0xx_fl_rcc.c fm33lc0xx_fl_crc.c fm33lc0xx_fl_uart.c fm33lc0xx_fl_lpuart.c fm33lc0xx_fl_gpio.c fm33lc0xx_fl_dma.c
    libraries/FM33LC0xx_FL_Driver/CMSIS/: system_fm33lc0xx.c
  group Kernel
    ../../src/: components.c mempool.c timer.c kservice.c idle.c object.c thread.c ipc.c irq.c mem.c clock.c scheduler.c device.c
