# IAR project fm3_easy_kit.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MB9BF506R Fujitsu MB9BF506R
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ; ..\CMSIS; ..\..\..\include; ..\..\..\components\finsh; ..\..\..\components\dfs\include; ..\..\..\components\dfs\filesystems\elmfat
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: 
  ILINK.IlinkOutputFile: fm3_easy_kit.out
  ILINK.IlinkIcfFile: mb9bf506.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS
    ../CMSIS/: core_cm3.c start_iar.S system_mb9bf50x.c
  group Filesystem
    ../../../components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
    ../../../components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
  group Finsh
    ../../../components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c shell.c symbol.c
  group FM3
    ../../../libcpu/arm/cortex-m3/: context_iar.S cpuport.c
  group Kernel
    ../../../src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c module.c object.c rtm.c scheduler.c slab.c thread.c timer.c
  group Startup
    ./: application.c board.c led.c nand.c serial.c startup.c
