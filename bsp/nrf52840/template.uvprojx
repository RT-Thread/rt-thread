# Keil uVision project template.uvprojx, settings and files
target rtthread (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.28.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CONFIG_NFCT_PINS_AS_GPIOS FLOAT_ABI_HARD NRF52840_XXAA BLE_STACK_SUPPORT_REQD NRF_SD_BLE_API_VERSION=6 S140 SOFTDEVICE_PRESENT SWI_DISABLE0
  c misc: --reduce_paths
  asm define: as above
  asm misc: --cpreproc_opts=-DCONFIG_NFCT_PINS_AS_GPIOS,-DFLOAT_ABI_HARD,-DNRF52840_XXAA,-DBLE_STACK_SUPPORT_REQD,-DNRF_SD_BLE_API_VERSION=6,-DS140,-DSOFTDEVICE_PRESENT,-DSWI_DISABLE0
  memory RVCT4: ROM 0x26000 size 0xb8000
  memory RVCT9: RAM 0x20002d18 size 0x3d2e8
  link misc: --diag_suppress 6330
