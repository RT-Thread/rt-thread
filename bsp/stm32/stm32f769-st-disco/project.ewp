# IAR project project.ewp, settings and files
configuration rt-thread (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407ZG ST STM32F407ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F767xx; __RTTHREAD__; USE_HAL_DRIVER
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\components\finsh; ..\libraries\STM32F7xx_HAL\CMSIS\Include; ..\..\..\components\drivers\include; ..\..\..\components\libc\compilers\common; ..\..\..\components\libc\compilers\common\nogcc; board\CubeMX_Config\Inc; ..\libraries\STM32F7xx_HAL\CMSIS\Device\ST\STM32F7xx\Include; ..\..\..\examples\utest\testcases\kernel; .; ..\libraries\HAL_Drivers\config; board; ..\libraries\HAL_Drivers; ..\..\..\components\net\lwip-2.0.2\src\include\netif; ..\..\..\components\net\lwip-2.0.2\src\arch\include; ..\..\..\components\net\lwip-2.0.2\src\include; applications; ..\..\..\include; ..\..\..\components\net\lwip-2.0.2\src\include\posix; ..\..\..\libcpu\arm\common; ..\..\..\libcpu\arm\cortex-m7; ..\..\..\components\net\lwip-2.0.2\src; ..\..\..\components\net\lwip-2.0.2\src\include\ipv4; ..\libraries\STM32F7xx_HAL\STM32F7xx_HAL_Driver\Inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../../rtthread.bin
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: main.c
  group CPU
    ../../../libcpu/arm/common/: div0.c showmem.c backtrace.c
    ../../../libcpu/arm/cortex-m7/: cpuport.c context_iar.S cpu_cache.c
  group DeviceDrivers
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/src/: workqueue.c dataqueue.c pipe.c ringbuffer.c completion.c waitqueue.c ringblk_buf.c
  group Drivers
    board/: board.c
    ../libraries/STM32F7xx_HAL/CMSIS/Device/ST/STM32F7xx/Source/Templates/iar/: startup_stm32f767xx.s
    board/CubeMX_Config/Src/: stm32f7xx_hal_msp.c
    ../libraries/HAL_Drivers/: drv_gpio.c drv_usart.c drv_common.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c cmd.c
  group Kernel
    ../../../src/: object.c mempool.c timer.c ipc.c components.c irq.c mem.c clock.c kservice.c scheduler.c idle.c thread.c device.c
  group libc
    ../../../components/libc/compilers/common/: time.c
  group Libraries
    ../libraries/STM32F7xx_HAL/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_gpio.c stm32f7xx_hal.c stm32f7xx_hal_cryp_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_sram.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_crc.c stm32f7xx_hal_cortex.c stm32f7xx_hal_uart_ex.c stm32f7xx_hal_usart.c stm32f7xx_hal_exti.c stm32f7xx_hal_rng.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_cec.c stm32f7xx_hal_dma.c stm32f7xx_hal_uart.c stm32f7xx_hal_cryp.c
    ../libraries/STM32F7xx_HAL/CMSIS/Device/ST/STM32F7xx/Source/Templates/: system_stm32f7xx.c
  group lwIP
    ../../../components/net/lwip-2.0.2/src/api/: netdb.c sockets.c netifapi.c tcpip.c netbuf.c api_lib.c err.c api_msg.c
    ../../../components/net/lwip-2.0.2/src/core/: ip.c netif.c sys.c init.c memp.c raw.c tcp_out.c inet_chksum.c stats.c tcp_in.c dns.c timeouts.c udp.c pbuf.c def.c tcp.c
    ../../../components/net/lwip-2.0.2/src/core/ipv4/: autoip.c ip4_addr.c dhcp.c etharp.c ip4.c ip4_frag.c icmp.c igmp.c
    ../../../components/net/lwip-2.0.2/src/netif/: ethernet.c ethernetif.c lowpan6.c
    ../../../components/net/lwip-2.0.2/src/apps/ping/: ping.c
    ../../../components/net/lwip-2.0.2/src/arch/: sys_arch.c
