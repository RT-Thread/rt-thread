# Keil uVision project project.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: V85XX Generic
  pack: Vango.V85XX.4.0.2
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: template
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: V85xx, USE_STDPERIPH_DRIVER, __CLK_TCK=RT_TICK_PER_SECOND, __RTTHREAD__, USE_TARGET_DRIVER, RT_USING_ARM_LIBC
  c include: applications;..\..\libcpu\arm\common;..\..\libcpu\arm\cortex-m0;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\drivers\include;drivers;..\..\components\dfs\include;..\..\components\dfs\filesystems\devfs;..\..\components\finsh;.;..\..\include;..\..\components\libc\compilers\armlibc;..\..\components\libc\compilers\common;..\..\components\libc\compilers\common\nogcc;..\..\examples\utest\testcases\kernel;Libraries\CMSIS\Vango\V85xx\Include;Libraries\CMSIS;Libraries\VangoV85xx_standard_peripheral\Include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Applications
    applications/: main.c
  group CPU
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../libcpu/arm/cortex-m0/: cpuport.c context_rvds.S
  group DeviceDrivers
    ../../components/drivers/misc/: pin.c
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/src/: workqueue.c pipe.c ringblk_buf.c completion.c dataqueue.c ringbuffer.c waitqueue.c
  group Drivers
    drivers/: drv_gpio.c drv_usart.c board.c
  group Filesystem
    ../../components/dfs/src/: dfs_posix.c dfs_poll.c dfs_file.c dfs.c dfs_fs.c dfs_select.c
    ../../components/dfs/filesystems/devfs/: devfs.c
  group Finsh
    ../../components/finsh/: shell.c msh.c msh_file.c cmd.c
  group Kernel
    ../../src/: mempool.c device.c kservice.c timer.c idle.c components.c object.c clock.c thread.c ipc.c scheduler.c irq.c mem.c
  group libc
    ../../components/libc/compilers/armlibc/: libc.c mem_std.c stdio.c syscalls.c
    ../../components/libc/compilers/common/: stdlib.c unistd.c delay.c time.c
  group Vango_Lib
    Libraries/VangoV85xx_standard_peripheral/Source/: lib_uart.c lib_lcd.c lib_gpio.c lib_flash.c lib_iso7816.c lib_wdt.c lib_crypt.c lib_ana.c lib_pmu.c lib_adc.c lib_dma.c lib_i2c.c lib_spi.c lib_version.c lib_misc.c lib_comp.c lib_adc_tiny.c lib_pwm.c lib_tmr.c lib_u32k.c lib_rtc.c lib_clk.c
    Libraries/CMSIS/Vango/V85xx/Source/: lib_CodeRAM.c system_target.c lib_cortex.c lib_LoadNVR.c
    Libraries/CMSIS/Vango/V85xx/Source/Keil5/: startup_target.S
