# Keil uVision project template.uvprojx, settings and files
target Target_1 (6180000::V6.18::ARMCLANG)
  device: R7FA2E2A7 Renesas
  pack: Renesas.RA_DFP.6.0.0
  cpu: CPUTYPE("Cortex-M23")      CLOCK(12000000) ELITTLE
  output: rtthread +hex
  c flags: v6Lang=3 v6LangP=6 wLevel=1
  c misc: @via/rasc_armclang.via
  c include: ..\..\..\include\klibc;..\..\..\libcpu\arm\cortex-m23;.\board\ports;.\board;..\libraries\HAL_Drivers;..\libraries\HAL_Drivers\config\ra2e2;..\..\..\include;..\..\..\components\libc\compilers\common\extension;..\..\..\components\finsh;..\..\..\components\drivers\include;..\..\..\components\finsh;..\libraries\HAL_Drivers\config;..\ra2e2-ek;..\..\..\components\drivers\ipc
  asm misc: --via=via/rasc_armasm.via
  scatter file: .\script\fsp.scat
  link misc: --via=via/rasc_armlink.via
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_entry.c
software components: Flex Software:RA Configuration 1.0.0
