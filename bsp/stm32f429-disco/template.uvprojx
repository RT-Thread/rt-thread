# Keil uVision project template.uvprojx, settings and files
target rt-thread_stm32f42x (ARM-ADS)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.8.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rtthread-stm32f42x
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F429_439xx
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
