# Keil uVision project project.uvprojx, settings and files
target rtthread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MIMXRT1064DVL6A NXP
  pack: NXP.MIMXRT1064_DFP.10.0.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x00000000,0x020000) IROM(0x70000000,0x400000) XRAM(0x20200000,0x0c0000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rtthread
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: XIP_BOOT_HEADER_ENABLE=1, __RTTHREAD__, SKIP_SYSCLK_INIT, __STDC_LIMIT_MACROS, CPU_MIMXRT1064DVL6A, XIP_EXTERNAL_FLASH=1, __CLK_TCK=RT_TICK_PER_SECOND, RT_USING_ARMLIBC, XIP_BOOT_HEADER_DCD_ENABLE=1, FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1, EVK_MCIMXRM, RT_USING_LIBC, __FPU_PRESENT=1
  c misc: --library_interface=armcc --library_type=standardlib --diag_suppress=66,1296,186
  c include: ..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\drivers\include;..\libraries\MIMXRT1064\MIMXRT1064\drivers;..\..\..\..\..\components\libc\compilers\common\include;..\..\..\..\..\components\libc\compilers\common\extension;board\MCUX_Config;..\..\..\..\..\libcpu\arm\common;..\..\..\..\..\components\finsh;..\..\..\..\..\components\drivers\include;xip;..\..\..\..\..\components\libc\posix\ipc;..\..\..\..\..\components\drivers\include;applications;..\..\..\..\..\include;board\ports;..\libraries\drivers;..\..\..\..\..\components\libc\posix\io\epoll;..\..\..\..\..\components\libc\compilers\common\extension\fcntl\octal;board;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\libc\posix\io\poll;..\..\..\..\..\components\drivers\phy;.;..\libraries\MIMXRT1064\CMSIS\Include;..\..\..\..\..\components\libc\posix\io\eventfd;..\..\..\..\..\components\drivers\smp_call;..\..\..\..\..\libcpu\arm\cortex-m7;..\libraries\MIMXRT1064\MIMXRT1064
  memory RVCT4: ROM 0x70000000 size 0x400000
  memory RVCT6: RAM 0x20200000 size 0xc0000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\board\linker_scripts\link.sct
  link misc: --keep=*(.boot_hdr.ivt)--keep=*(.boot_hdr.boot_data)--keep=*(.boot_hdr.dcd_data)--keep=*(.boot_hdr.conf)
  group Applications
    applications/: main.c
  group Compiler
    ../../../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../../../components/drivers/core/: device.c
    ../../../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../../components/drivers/pin/: dev_pin.c
    ../../../../../components/drivers/serial/: dev_serial.c
  group Drivers
    board/MCUX_Config/: clock_config.c pin_mux.c
    board/: board.c
    ../libraries/drivers/: drv_common.c drv_gpio.c drv_uart.c
  group Finsh
    ../../../../../components/finsh/: cmd.c shell.c msh_parse.c msh.c
  group Kernel
    ../../../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    ../../../../../src/klibc/: kstring.c kerrno.c rt_vsnprintf_tiny.c kstdio.c rt_vsscanf.c
  group libcpu
    ../../../../../libcpu/arm/common/: div0.c showmem.c
    ../../../../../libcpu/arm/cortex-m7/: context_rvds.S cpu_cache.c cpuport.c
  group Libraries
    ../libraries/MIMXRT1064/MIMXRT1064/drivers/: fsl_cache.c fsl_clock.c fsl_lpuart.c fsl_common.c fsl_gpio.c
    ../libraries/MIMXRT1064/MIMXRT1064/: system_MIMXRT1064.c
    ../libraries/MIMXRT1064/MIMXRT1064/arm/: startup_MIMXRT1064.s
  group xip
    xip/: evkmimxrt1064_flexspi_nor_config.c evkmimxrt1064_sdram_ini_dcd.c fsl_flexspi_nor_boot.c
