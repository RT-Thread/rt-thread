# IAR project project.ewp, settings and files
configuration rtthread (ARM, debug)
  General.OGChipSelectEditMenu: STM32H743ZI ST STM32H743ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: STM32H747xx; CORE_CM7; __RTTHREAD__; USE_HAL_DRIVER
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: board\CubeMX_Config\CM7\Inc; ..\..\..\components\finsh; ..\..\..\libcpu\arm\common; ..\..\..\libcpu\arm\cortex-m7; ..\..\..\components\drivers\include; ..\libraries\STM32H7xx_HAL\STM32H7xx_HAL_Driver\Inc; ..\..\..\examples\utest\testcases\kernel; .; ..\..\..\components\libc\compilers\common\nogcc; ..\libraries\HAL_Drivers\config; board; ..\..\..\components\libc\compilers\common; ..\libraries\STM32H7xx_HAL\CMSIS\Include; ..\libraries\STM32H7xx_HAL\CMSIS\Device\ST\STM32H7xx\Include; ..\..\..\include; ..\libraries\HAL_Drivers
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../../rtthread.bin
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: main.c
  group CPU
    ../../../libcpu/arm/common/: div0.c backtrace.c showmem.c
    ../../../libcpu/arm/cortex-m7/: cpuport.c cpu_cache.c context_iar.S
  group DeviceDrivers
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/src/: ringbuffer.c workqueue.c waitqueue.c completion.c dataqueue.c pipe.c ringblk_buf.c
  group Drivers
    board/: board.c
    board/CubeMX_Config/CM7/Src/: stm32h7xx_hal_msp.c
    ../libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32H7xx/Source/Templates/iar/: startup_stm32h747xx.s
    ../libraries/HAL_Drivers/: drv_gpio.c drv_usart.c drv_common.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c cmd.c
  group Kernel
    ../../../src/: object.c thread.c clock.c ipc.c timer.c device.c kservice.c components.c mempool.c scheduler.c mem.c idle.c irq.c
  group libc
    ../../../components/libc/compilers/common/: time.c
  group Libraries
    ../libraries/STM32H7xx_HAL/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_rcc.c stm32h7xx_hal_pwr.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_sram.c stm32h7xx_hal_cortex.c stm32h7xx_hal_cryp_ex.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_cryp.c stm32h7xx_hal_usart.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal.c stm32h7xx_hal_dma.c stm32h7xx_hal_uart.c stm32h7xx_hal_comp.c stm32h7xx_hal_rng.c stm32h7xx_hal_crc.c stm32h7xx_hal_cec.c stm32h7xx_hal_pwr_ex.c
    ../libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
