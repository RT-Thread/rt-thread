# IAR project project.ewp, settings and files
configuration rt-thread (ARM, debug)
  General.OGChipSelectEditMenu: STM32F072RB ST STM32F072RB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: RT_USING_DLIBC; __RTTHREAD__
  ICCARM.CCIncludePath2: libraries\HAL_Driver\Inc; ..\..\include; ..\..\libcpu\arm\cortex-m33; ..\..\components\libc\compilers\common\extension; ..\..\components\libc\compilers\common; ..\..\components\libc\posix\ipc; drivers; .; libraries\Device; applications; ..\..\components\libc\posix\io\poll; ..\..\components\libc\posix\io\stdio; libraries\CMSIS; ..\..\components\drivers\include; ..\..\libcpu\arm\common; ..\..\components\finsh
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../../rtthread.bin
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: drivers\linker_scripts\link.icf
  ILINK.IlinkAdditionalLibs: libraries\Device\libSystem_Accelerate.a; libraries\HAL_Driver\Src\libHAL_EFlash_EX.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: rtthread.bin
  ILINK.IlinkOutputFile: template.out
  group ACM32_HAL
    libraries/HAL_Driver/Src/: HAL_UART.c HAL_EXTI.c HAL_DMA.c HAL_GPIO.c HAL_EFlash.c
    libraries/Device/: Startup_ACM32F4_iar.s System_ACM32F4.c
  group Applications
    applications/: main.c
  group Compiler
    ../../components/libc/compilers/common/: time.c stdlib.c
    ../../components/libc/compilers/dlib/: syscall_close.c syscall_read.c syscalls.c syscall_mem.c syscall_lseek.c syscall_write.c syscall_open.c environ.c syscall_remove.c
  group CPU
    ../../libcpu/arm/common/: div0.c backtrace.c showmem.c
    ../../libcpu/arm/cortex-m33/: context_iar.S syscall_iar.S trustzone.c cpuport.c
  group DeviceDrivers
    ../../components/drivers/ipc/: waitqueue.c pipe.c ringblk_buf.c dataqueue.c ringbuffer.c completion.c workqueue.c
    ../../components/drivers/misc/: pin.c
    ../../components/drivers/serial/: serial.c
  group Drivers
    drivers/: board.c drv_gpio.c drv_uart.c
  group Finsh
    ../../components/finsh/: shell.c msh.c cmd.c
  group Kernel
    ../../src/: components.c kservice.c clock.c object.c irq.c idle.c ipc.c mem.c mempool.c scheduler.c timer.c thread.c device.c
