# Keil uVision project project.uvproj, settings and files
target rtthread (ARM-ADS)
  device: AT91SAM9260 Atmel
  cpu: IRAM(0x200000-0x200FFF) IRAM2(0x300000-0x300FFF) IROM(0x100000-0x107FFF) CLOCK(18432000) CPUTYPE(ARM926EJ-S)
  output: nuc972-rthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 uC99=1 wLevel=2
  c define: RT_USING_ARM_LIBC
  c include: Applications;.;Drivers;.;D;:;..\..\..\..\..;D;e;v;e;l;o;p;e;r;..\..\..\..\..;R;T;_;C;o;d;e;..\..\..\..\..;r;t;-;t;h;r;e;a;d;-;3;.;0;..\..\..\..\..;b;s;p;..\..\..\..\..;n;u;v;o;t;o;n;_;n;u;c;9;7;2;..\..\..\..\..;P;l;a;t;f;o;r;m;..\..\include;..\..\libcpu\arm\arm926;..\..\libcpu\arm\common;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\drivers\spi;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\finsh;..\..\components\gui\include;..\..\components\libc\compilers\armlibc
  asm include: .\platform
  memory RVCT1: ROM 0x0 size 0x80000
  memory RVCT6: RAM 0x80000 size 0x800000
  scatter file: .\nuc970_ram.sct
  link misc: --keep *.o(.rti_fn.*)   --keep *.o(FSymTab)
  group Applications
    Applications/: main.c rtgui_demo.c task_blink.c
  group Drivers
    Drivers/: board.c nuc97x_adc.c nuc97x_etimer.c nuc97x_gpio.c nuc97x_interrupt.c nuc97x_lcd.c nuc97x_sys.c nuc97x_timer.c nuc97x_uart.c touch.c
  group Platform
    Platform/: rt_low_level_init.c
  group Kernel
    ../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler.c signal.c slab.c thread.c timer.c
  group ARM926
    ../../libcpu/arm/arm926/: cpuport.c mmu.c stack.c trap.c context_rvds.S start_rvds.S
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
  group DeviceDrivers
    ../../components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    ../../components/drivers/misc/: pin.c
    ../../components/drivers/mtd/: mtd_nor.c mtd_nand.c
    ../../components/drivers/rtc/: rtc.c
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/spi/: spi_core.c spi_dev.c spi_flash_w25qxx.c
    ../../components/drivers/src/: completion.c dataqueue.c pipe.c ringbuffer.c waitqueue.c workqueue.c
    ../../components/drivers/watchdog/: watchdog.c
  group finsh
    ../../components/finsh/: shell.c symbol.c cmd.c msh.c msh_cmd.c msh_file.c
  group GUIEngine
    ../../components/gui/src/: asc12font.c asc16font.c blit.c box.c color.c container.c dc.c dc_blend.c dc_buffer.c dc_client.c dc_hw.c dc_rotozoom.c dc_trans.c filerw.c font.c font_bmp.c font_fnt.c font_freetype.c font_hz_bmp.c font_hz_file.c hz12font.c hz16font.c image.c image_bmp.c image_container.c image_hdc.c image_jpg.c image_png.c image_xpm.c matrix.c mouse.c region.c rtgui_app.c rtgui_driver.c rtgui_object.c rtgui_system.c server.c title.c topwin.c widget.c window.c
  group libc
    ../../components/libc/compilers/armlibc/: libc.c libc_syms.c mem_std.c stdio.c stubs.c time.c
