# IAR project project.ewp, settings and files
configuration rt-thread (ARM, debug)
  General.OGChipSelectEditMenu: N32G4FRME Nations N32G4FRME
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: N32G4FR; __RTTHREAD__; CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; USE_STDPERIPH_DRIVER; __RT_IPC_SOURCE__; __RT_KERNEL_SOURCE__
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\components\drivers\spi; ..\..\..\components\finsh; board; ..\..\..\libcpu\arm\common; ..\libraries\n32_drivers; ..\..\..\components\drivers\phy; ..\..\..\include; ..\..\..\components\libc\posix\io\epoll; ..\..\..\components\libc\posix\ipc; ..\libraries\N32G4FR_Firmware_Library\CMSIS; ..\..\..\components\libc\compilers\common\include; ..\libraries\N32G4FR_Firmware_Library\n32g4fr_std_periph_driver\inc; ..\..\..\components\libc\compilers\common\extension; ..\..\..\components\drivers\smp_call; .; ..\libraries\N32G4FR_Firmware_Library\CMSIS\core; ..\..\..\components\libc\posix\io\eventfd; ..\libraries\N32G4FR_Firmware_Library\CMSIS\device; ..\..\..\components\drivers\include; ..\libraries\n32_drivers\config; applications; ..\..\..\components\libc\posix\io\poll; ..\..\..\libcpu\arm\cortex-m4; ..\..\..\components\libc\compilers\common\extension\fcntl\octal
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../../rtthread.bin
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: main.c
  group Compiler
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
  group DeviceDrivers
    ../../../components/drivers/can/: dev_can.c
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/clock_time/: clock_timer.c
    ../../../components/drivers/i2c/: dev_i2c_bit_ops.c dev_i2c_core.c dev_i2c_dev.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/misc/: adc.c dac.c
    ../../../components/drivers/pin/: dev_pin.c
    ../../../components/drivers/rtc/: dev_rtc.c
    ../../../components/drivers/serial/: dev_serial.c
    ../../../components/drivers/spi/: dev_spi.c dev_spi_core.c
    ../../../components/drivers/watchdog/: dev_watchdog.c
  group Drivers
    ../libraries/N32G4FR_Firmware_Library/CMSIS/device/startup/: startup_n32g4fr_EWARM.s
    board/: board.c
    ../libraries/n32_drivers/: drv_adc.c drv_can.c drv_dac.c drv_gpio.c drv_timer.c drv_rtc.c drv_spi.c drv_usart.c drv_wdt.c
  group Finsh
    ../../../components/finsh/: cmd.c msh.c msh_parse.c shell.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    ../../../src/klibc/: kstring.c rt_vsscanf.c rt_vsnprintf_tiny.c kstdio.c kerrno.c
  group libcpu
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m4/: context_iar.S cpuport.c
  group libraries
    ../libraries/N32G4FR_Firmware_Library/n32g4fr_std_periph_driver/src/: n32g4fr_usart.c n32g4fr_adc.c n32g4fr_rtc.c n32g4fr_exti.c n32g4fr_spi.c n32g4fr_rcc.c n32g4fr_gpio.c n32g4fr_can.c n32g4fr_i2c.c n32g4fr_dac.c n32g4fr_iwdg.c n32g4fr_tim.c misc.c n32g4fr_wwdg.c
    ../libraries/N32G4FR_Firmware_Library/CMSIS/device/: system_n32g4fr.c
