# Keil uVision project template.uvprojx, settings and files
target rtthread-frdm-mcxc444 (6160000::V6.16::ARMCLANG)
  device: MCXC444VLH NXP
  pack: NXP.MCXC444_DFP.17.0.0
  cpu: IRAM(0x1fffe000,0x8000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: rtthread
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=3
  c define: RT_USING_ARM_LIBC
  c misc: --target=arm-arm-none-eabi
  asm misc: -x assembler-with-cpp
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x8000
  scatter file: .\board\linker_scripts\MCXC444_flash.scf
  link misc: --keep *.o(.rti_fn.*)   --keep *.o(FSymTab) --keep *.o(VSymTab)
