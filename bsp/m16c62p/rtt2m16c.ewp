# IAR project rtt2m16c.ewp, settings and files
configuration Debug (M16C, debug)
  General.GData16HeapSize: 0x1000
  General.GFarHeapSize: 0x400
  General.GData20HeapSize: 0x400
  General.GStackSize: 0x80
  General.GIStackSize: 0x40
  General.OGChipSelectMenu: M30627FHP M30627FHP
  ICCM16C.newCCIncludePaths: ; ..\..\include\; ..\..\components\finsh\
  ICCM16C.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  XLINK.XclFile: lnkm30627fhp.xcl
  XLINK.XlinkStackSize: 1
  XLINK.XlinkInterruptStackSize: 1
configuration Release (M16C)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  General.OGChipSelectMenu: m16cgen Generic M16C
  XLINK.XclFile: lnk0t.xcl
  group bsp/m16c62p
    ./: application.c board.c bsp.c cstartup.s34 interrupts.s34 lnkm30627fhp.xcl rtconfig.h startup.c uart.c vectors.s34
  group finsh
    ../../components/finsh/: cmd.c finsh.h finsh_compiler.c finsh_error.c finsh_error.h finsh_heap.c finsh_heap.h finsh_init.c finsh_node.c finsh_node.h finsh_ops.c finsh_ops.h finsh_parser.c finsh_parser.h finsh_token.c finsh_token.h finsh_var.c finsh_var.h finsh_vm.c finsh_vm.h shell.c symbol.c
  group include
    ../../include/: rtdef.h rthw.h rtthread.h
  group kernel
    ../../src/: clock.c device.c idle.c ipc.c irq.c kservice.c kservice.h mem.c mempool.c object.c scheduler.c slab.c thread.c timer.c
  group libcpu/m16c
    ../../libcpu/m16c/: context.asm interrupt.c stack.c
