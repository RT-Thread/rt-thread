<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/KsdkPlatformLib_KL25Z4.ewp</path>
  </project>
</workspace>
