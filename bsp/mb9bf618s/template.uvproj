# Keil uVision project template.uvproj, settings and files
target rtthread (ARM-ADS)
  device: MB9BF618S Fujitsu Semiconductors
  cpu: IRAM(0x20000000-0x2000FFFF) IRAM2(0x1FFF0000-0x1FFFFFFF) IROM(0x00000000-0x000FFFFF) CLOCK(4000000) CPUTYPE("Cortex-M3")
  output: rtthread-fm3
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x20000
  scatter file: rtthread-fm3.sct
