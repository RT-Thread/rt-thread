# IAR project project.ewp, settings and files
configuration rt-thread (ARM, debug)
  General.OGChipSelectEditMenu: STM32F072RB ST STM32F072RB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: __RTTHREAD__; RT_USING_DLIBC
  ICCARM.CCIncludePath2: libraries\HAL_Driver\Inc; ..\..\include; applications; ..\..\components\libc\compilers\dlib; drivers; ..\..\components\libc\compilers\common; .; libraries\Device; ..\..\components\libc\compilers\common\nogcc; ..\..\examples\utest\testcases\kernel; libraries\CMSIS; ..\..\libcpu\arm\cortex-m0; ..\..\components\drivers\include; ..\..\libcpu\arm\common; ..\..\components\finsh
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../../rtthread.bin
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: drivers\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: rtthread.bin
  ILINK.IlinkOutputFile: template.out
  group ACM32_HAL
    libraries/HAL_Driver/Src/: HAL_IWDT.c HAL_UART.c HAL_EXTI.c HAL_DMA.c HAL_TIMER.c HAL_ADC.c HAL_WDT.c HAL_GPIO.c
    libraries/Device/: Startup_ACM32F0x0_iar.s System_ACM32F0x0.c
  group Applications
    applications/: main.c
  group CPU
    ../../libcpu/arm/common/: showmem.c backtrace.c div0.c
    ../../libcpu/arm/cortex-m0/: context_iar.S cpuport.c
  group DeviceDrivers
    ../../components/drivers/hwtimer/: hwtimer.c
    ../../components/drivers/misc/: adc.c pin.c
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/src/: waitqueue.c workqueue.c ringbuffer.c ringblk_buf.c pipe.c completion.c dataqueue.c
    ../../components/drivers/watchdog/: watchdog.c
  group Drivers
    drivers/: drv_gpio.c drv_wdt.c drv_uart.c drv_hwtimer.c drv_adc.c board.c
  group Finsh
    ../../components/finsh/: shell.c msh.c
  group Kernel
    ../../src/: idle.c kservice.c mem.c mempool.c ipc.c components.c thread.c irq.c timer.c clock.c object.c device.c scheduler.c
  group libc
    ../../components/libc/compilers/common/: time.c stdlib.c
    ../../components/libc/compilers/dlib/: syscall_mem.c syscall_open.c syscall_lseek.c stdio.c syscall_close.c environ.c syscall_read.c libc.c syscall_write.c syscalls.c syscall_remove.c
