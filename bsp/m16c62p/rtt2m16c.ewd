<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>M16C</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>C-SPY</name>
      <archiveVersion>2</archiveVersion>
      <data>
        <version>9</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>CInput</name>
          <state>1</state>
        </option>
        <option>
          <name>MacOverride</name>
          <state>0</state>
        </option>
        <option>
          <name>MacFile</name>
          <state></state>
        </option>
        <option>
          <name>Variant</name>
          <version>0</version>
          <state>0</state>
        </option>
        <option>
          <name>CProcessor</name>
          <state>0</state>
        </option>
        <option>
          <name>RunToEnable</name>
          <state>1</state>
        </option>
        <option>
          <name>RunToName</name>
          <state>main</state>
        </option>
        <option>
          <name>DebuggerCpuCore</name>
          <state>0</state>
        </option>
        <option>
          <name>DynDriver</name>
          <state>M16CEMUE8A</state>
        </option>
        <option>
          <name>dDllSlave</name>
          <state>0</state>
        </option>
        <option>
          <name>DdfFileSlave</name>
          <state>1</state>
        </option>
        <option>
          <name>DdfOverrideP7</name>
          <state>0</state>
        </option>
        <option>
          <name>DdfFileName</name>
          <state>$TOOLKIT_DIR$\config\M30627FHP.ddf</state>
        </option>
        <option>
          <name>OCDownloadFlashDownload</name>
          <state>0</state>
        </option>
        <option>
          <name>OCDownloadFlashLoader</name>
          <state>$TOOLKIT_DIR$\config\flashloader\</state>
        </option>
        <option>
          <name>OCDownloadFlashLoaderArgs</name>
          <state></state>
        </option>
        <option>
          <name>OCDownloadFlashBaseAddrOverride</name>
          <state>0</state>
        </option>
        <option>
          <name>OCDownloadFlashBaseAddr</name>
          <state></state>
        </option>
        <option>
          <name>OCDownloadSuppressDownload</name>
          <state>0</state>
        </option>
        <option>
          <name>OCDownloadVerifyAll</name>
          <state>0</state>
        </option>
        <option>
          <name>OCDownloadFlashLoaderSlave</name>
          <state></state>
        </option>
        <option>
          <name>CExtraOptionsCheck</name>
          <state>0</state>
        </option>
        <option>
          <name>CExtraOptions</name>
          <state></state>
        </option>
        <option>
          <name>OCImagesSuppressCheck1</name>
          <state>0</state>
        </option>
        <option>
          <name>OCImagesPath1</name>
          <state></state>
        </option>
        <option>
          <name>OCImagesSuppressCheck2</name>
          <state>0</state>
        </option>
        <option>
          <name>OCImagesPath2</name>
          <state></state>
        </option>
        <option>
          <name>OCImagesSuppressCheck3</name>
          <state>0</state>
        </option>
        <option>
          <name>OCImagesPath3</name>
          <state></state>
        </option>
      </data>
    </settings>
    <settings>
      <name>M16CEMU</name>
      <archiveVersion>1</archiveVersion>
      <data>
        <version>0</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>OCEmuLanAddress</name>
          <state>0.0.0.0</state>
        </option>
        <option>
          <name>OCEmuCommucationType</name>
          <state>0</state>
        </option>
        <option>
          <name>OCEmuLanPort</name>
          <state>0x7501</state>
        </option>
        <option>
          <name>OCEmuUseUSBSerialNo</name>
          <state>0</state>
        </option>
        <option>
          <name>OCEmuUSBSerialNo</name>
          <state></state>
        </option>
        <option>
          <name>DoEmuLogfile</name>
          <state>0</state>
        </option>
        <option>
          <name>EmuLogFile</name>
          <state>cspycomm.log</state>
        </option>
      </data>
    </settings>
    <settings>
      <name>M16CEMUCPE</name>
      <archiveVersion>1</archiveVersion>
      <data>
        <version>0</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>OCEmuUseUSBSerialNo</name>
          <state>0</state>
        </option>
        <option>
          <name>OCEmuUSBSerialNo</name>
          <state></state>
        </option>
        <option>
          <name>DoEmuLogfile</name>
          <state>0</state>
        </option>
        <option>
          <name>EmuLogFile</name>
          <state>cspycomm.log</state>
        </option>
      </data>
    </settings>
    <settings>
      <name>M16CEMUE100</name>
      <archiveVersion>1</archiveVersion>
      <data>
        <version>0</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>OCEmuUseUSBSerialNo</name>
          <state>0</state>
        </option>
        <option>
          <name>OCEmuUSBSerialNo</name>
          <state></state>
        </option>
        <option>
          <name>DoEmuLogfile</name>
          <state>0</state>
        </option>
        <option>
          <name>EmuLogFile</name>
          <state>cspycomm.log</state>
        </option>
      </data>
    </settings>
    <settings>
      <name>M16CEMUE8</name>
      <archiveVersion>1</archiveVersion>
      <data>
        <version>0</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>CEmue8Mandatory</name>
          <state>1</state>
        </option>
      </data>
    </settings>
    <settings>
      <name>M16CEMUE8A</name>
      <archiveVersion>1</archiveVersion>
      <data>
        <version>0</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>CEmue8aMandatory</name>
          <state>1</state>
        </option>
      </data>
    </settings>
    <settings>
      <name>M16CROM</name>
      <archiveVersion>1</archiveVersion>
      <data>
        <version>1</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>PortP7</name>
          <version>0</version>
          <state>0</state>
        </option>
        <option>
          <name>BaudP7</name>
          <version>0</version>
          <state>7</state>
        </option>
        <option>
          <name>ParityP7</name>
          <version>0</version>
          <state>0</state>
        </option>
        <option>
          <name>DataBitsP7</name>
          <version>0</version>
          <state>0</state>
        </option>
        <option>
          <name>StopBitsP7</name>
          <version>0</version>
          <state>1</state>
        </option>
        <option>
          <name>HandshakeP7</name>
          <version>0</version>
          <state>0</state>
        </option>
        <option>
          <name>AAllP7</name>
          <state>1</state>
        </option>
        <option>
          <name>DoLogfileP7</name>
          <state>0</state>
        </option>
        <option>
          <name>LogFileP7</name>
          <state>cspycomm.log</state>
        </option>
        <option>
          <name>ExitBreakP7</name>
          <state>0</state>
        </option>
        <option>
          <name>CRomMonitorMandatory</name>
          <state>0</state>
        </option>
      </data>
    </settings>
    <settings>
      <name>M16CSIM</name>
      <archiveVersion>2</archiveVersion>
      <data>
        <version>0</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>CSimMandatory</name>
          <state>1</state>
        </option>
      </data>
    </settings>
    <settings>
      <name>M16CUSBROM</name>
      <archiveVersion>1</archiveVersion>
      <data>
        <version>1</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>ExitBreakUSB</name>
          <state>0</state>
        </option>
        <option>
          <name>CUsbRomMonitorMandatory</name>
          <state>0</state>
        </option>
      </data>
    </settings>
    <debuggerPlugins>
      <plugin>
        <file>$TOOLKIT_DIR$\plugins\rtos\embOS\embOSPlugin.ewplugin</file>
        <loadFlag>0</loadFlag>
      </plugin>
      <plugin>
        <file>$TOOLKIT_DIR$\plugins\rtos\uCOS-II\uCOS-II-KA-CSpy.ewplugin</file>
        <loadFlag>0</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\CodeCoverage\CodeCoverage.ENU.ewplugin</file>
        <loadFlag>1</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\Orti\Orti.ENU.ewplugin</file>
        <loadFlag>0</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\Profiling\Profiling.ENU.ewplugin</file>
        <loadFlag>1</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\Stack\Stack.ENU.ewplugin</file>
        <loadFlag>1</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\SymList\SymList.ENU.ewplugin</file>
        <loadFlag>1</loadFlag>
      </plugin>
    </debuggerPlugins>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>M16C</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>C-SPY</name>
      <archiveVersion>2</archiveVersion>
      <data>
        <version>9</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>CInput</name>
          <state>1</state>
        </option>
        <option>
          <name>MacOverride</name>
          <state>0</state>
        </option>
        <option>
          <name>MacFile</name>
          <state></state>
        </option>
        <option>
          <name>Variant</name>
          <version>0</version>
          <state>0</state>
        </option>
        <option>
          <name>CProcessor</name>
          <state>0</state>
        </option>
        <option>
          <name>RunToEnable</name>
          <state>1</state>
        </option>
        <option>
          <name>RunToName</name>
          <state>main</state>
        </option>
        <option>
          <name>DebuggerCpuCore</name>
          <state>0</state>
        </option>
        <option>
          <name>DynDriver</name>
          <state>M16CSIM</state>
        </option>
        <option>
          <name>dDllSlave</name>
          <state>0</state>
        </option>
        <option>
          <name>DdfFileSlave</name>
          <state>1</state>
        </option>
        <option>
          <name>DdfOverrideP7</name>
          <state>0</state>
        </option>
        <option>
          <name>DdfFileName</name>
          <state></state>
        </option>
        <option>
          <name>OCDownloadFlashDownload</name>
          <state>0</state>
        </option>
        <option>
          <name>OCDownloadFlashLoader</name>
          <state>$TOOLKIT_DIR$\config\flashloader\</state>
        </option>
        <option>
          <name>OCDownloadFlashLoaderArgs</name>
          <state></state>
        </option>
        <option>
          <name>OCDownloadFlashBaseAddrOverride</name>
          <state>0</state>
        </option>
        <option>
          <name>OCDownloadFlashBaseAddr</name>
          <state></state>
        </option>
        <option>
          <name>OCDownloadSuppressDownload</name>
          <state>0</state>
        </option>
        <option>
          <name>OCDownloadVerifyAll</name>
          <state>0</state>
        </option>
        <option>
          <name>OCDownloadFlashLoaderSlave</name>
          <state></state>
        </option>
        <option>
          <name>CExtraOptionsCheck</name>
          <state>0</state>
        </option>
        <option>
          <name>CExtraOptions</name>
          <state></state>
        </option>
        <option>
          <name>OCImagesSuppressCheck1</name>
          <state>0</state>
        </option>
        <option>
          <name>OCImagesPath1</name>
          <state></state>
        </option>
        <option>
          <name>OCImagesSuppressCheck2</name>
          <state>0</state>
        </option>
        <option>
          <name>OCImagesPath2</name>
          <state></state>
        </option>
        <option>
          <name>OCImagesSuppressCheck3</name>
          <state>0</state>
        </option>
        <option>
          <name>OCImagesPath3</name>
          <state></state>
        </option>
      </data>
    </settings>
    <settings>
      <name>M16CEMU</name>
      <archiveVersion>1</archiveVersion>
      <data>
        <version>0</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>OCEmuLanAddress</name>
          <state>0.0.0.0</state>
        </option>
        <option>
          <name>OCEmuCommucationType</name>
          <state>0</state>
        </option>
        <option>
          <name>OCEmuLanPort</name>
          <state>0x7501</state>
        </option>
        <option>
          <name>OCEmuUseUSBSerialNo</name>
          <state>0</state>
        </option>
        <option>
          <name>OCEmuUSBSerialNo</name>
          <state></state>
        </option>
        <option>
          <name>DoEmuLogfile</name>
          <state>0</state>
        </option>
        <option>
          <name>EmuLogFile</name>
          <state>cspycomm.log</state>
        </option>
      </data>
    </settings>
    <settings>
      <name>M16CEMUCPE</name>
      <archiveVersion>1</archiveVersion>
      <data>
        <version>0</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>OCEmuUseUSBSerialNo</name>
          <state>0</state>
        </option>
        <option>
          <name>OCEmuUSBSerialNo</name>
          <state></state>
        </option>
        <option>
          <name>DoEmuLogfile</name>
          <state>0</state>
        </option>
        <option>
          <name>EmuLogFile</name>
          <state>cspycomm.log</state>
        </option>
      </data>
    </settings>
    <settings>
      <name>M16CEMUE100</name>
      <archiveVersion>1</archiveVersion>
      <data>
        <version>0</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>OCEmuUseUSBSerialNo</name>
          <state>0</state>
        </option>
        <option>
          <name>OCEmuUSBSerialNo</name>
          <state></state>
        </option>
        <option>
          <name>DoEmuLogfile</name>
          <state>0</state>
        </option>
        <option>
          <name>EmuLogFile</name>
          <state>cspycomm.log</state>
        </option>
      </data>
    </settings>
    <settings>
      <name>M16CEMUE8</name>
      <archiveVersion>1</archiveVersion>
      <data>
        <version>0</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>CEmue8Mandatory</name>
          <state>1</state>
        </option>
      </data>
    </settings>
    <settings>
      <name>M16CEMUE8A</name>
      <archiveVersion>1</archiveVersion>
      <data>
        <version>0</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>CEmue8aMandatory</name>
          <state>1</state>
        </option>
      </data>
    </settings>
    <settings>
      <name>M16CROM</name>
      <archiveVersion>1</archiveVersion>
      <data>
        <version>1</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>PortP7</name>
          <version>0</version>
          <state>0</state>
        </option>
        <option>
          <name>BaudP7</name>
          <version>0</version>
          <state>7</state>
        </option>
        <option>
          <name>ParityP7</name>
          <version>0</version>
          <state>0</state>
        </option>
        <option>
          <name>DataBitsP7</name>
          <version>0</version>
          <state>0</state>
        </option>
        <option>
          <name>StopBitsP7</name>
          <version>0</version>
          <state>1</state>
        </option>
        <option>
          <name>HandshakeP7</name>
          <version>0</version>
          <state>0</state>
        </option>
        <option>
          <name>AAllP7</name>
          <state>1</state>
        </option>
        <option>
          <name>DoLogfileP7</name>
          <state>0</state>
        </option>
        <option>
          <name>LogFileP7</name>
          <state>cspycomm.log</state>
        </option>
        <option>
          <name>ExitBreakP7</name>
          <state>0</state>
        </option>
        <option>
          <name>CRomMonitorMandatory</name>
          <state>0</state>
        </option>
      </data>
    </settings>
    <settings>
      <name>M16CSIM</name>
      <archiveVersion>2</archiveVersion>
      <data>
        <version>0</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>CSimMandatory</name>
          <state>1</state>
        </option>
      </data>
    </settings>
    <settings>
      <name>M16CUSBROM</name>
      <archiveVersion>1</archiveVersion>
      <data>
        <version>1</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>ExitBreakUSB</name>
          <state>0</state>
        </option>
        <option>
          <name>CUsbRomMonitorMandatory</name>
          <state>0</state>
        </option>
      </data>
    </settings>
    <debuggerPlugins>
      <plugin>
        <file>$TOOLKIT_DIR$\plugins\rtos\embOS\embOSPlugin.ewplugin</file>
        <loadFlag>0</loadFlag>
      </plugin>
      <plugin>
        <file>$TOOLKIT_DIR$\plugins\rtos\uCOS-II\uCOS-II-KA-CSpy.ewplugin</file>
        <loadFlag>0</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\CodeCoverage\CodeCoverage.ENU.ewplugin</file>
        <loadFlag>1</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\Orti\Orti.ENU.ewplugin</file>
        <loadFlag>0</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\Profiling\Profiling.ENU.ewplugin</file>
        <loadFlag>1</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\Stack\Stack.ENU.ewplugin</file>
        <loadFlag>1</loadFlag>
      </plugin>
      <plugin>
        <file>$EW_DIR$\common\plugins\SymList\SymList.ENU.ewplugin</file>
        <loadFlag>1</loadFlag>
      </plugin>
    </debuggerPlugins>
  </configuration>
</project>


