# IAR project project.ewp, settings and files
configuration rtthread_ram (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1189xxx8_M7 NXP MIMXRT1189xxx8_M7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: CPU_MIMXRT1189CVM8C_cm7; MIMXRT1189_cm7_SERIES; ARM_MATH_CM7; NDEBUG; __USE_SHMEM; MULTICORE_APP=1; XIP_EXTERNAL_FLASH=1; XIP_EXTERNAL_FLASH=1; __RTTHREAD__; CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; __RT_IPC_SOURCE__; __RT_KERNEL_SOURCE__
  ICCARM.CCIncludePath2: applications; ..\..\..\..\..\..\libcpu\arm\common; ..\..\..\..\..\..\libcpu\arm\cortex-m7; ..\..\..\..\..\..\components\drivers\include; ..\..\..\..\..\..\components\drivers\phy; ..\..\..\..\..\..\components\drivers\smp_call; board; board\MCUX_Config; board\ports; ..\..\libraries\drivers; ..\..\..\..\..\..\components\finsh; .; ..\..\..\..\..\..\include; ..\..\..\..\..\..\components\libc\compilers\common\include; ..\..\..\..\..\..\components\libc\compilers\common\extension; ..\..\..\..\..\..\components\libc\compilers\common\extension\fcntl\octal; ..\..\..\..\..\..\components\libc\posix\io\epoll; ..\..\..\..\..\..\components\libc\posix\io\eventfd; ..\..\..\..\..\..\components\libc\posix\io\poll; ..\..\..\..\..\..\components\libc\posix\ipc; packages\nxp-imxrt-sdk-latest\MIMXRT1180\CMSIS\Core\Include; packages\nxp-imxrt-sdk-latest\MIMXRT1180\CMSIS\Core\m-profile; packages\nxp-imxrt-sdk-latest\MIMXRT1180\MIMXRT1189; packages\nxp-imxrt-sdk-latest\MIMXRT1180\MIMXRT1189\drivers; packages\nxp-imxrt-sdk-latest\MIMXRT1180\MIMXRT1189\periph; packages\nxp-imxrt-sdk-latest\MIMXRT1180\MIMXRT1189\drivers\cm7; multicore; packages\nxp-imxrt-sdk-latest\MIMXRT1180\multicore\mcmgr\inc; packages\nxp-imxrt-sdk-latest\MIMXRT1180\multicore\mcmgr\inc\platform\imxrt1180; packages\nxp-imxrt-sdk-latest\MIMXRT1180\multicore\rpmsg-lite\lib\include; packages\nxp-imxrt-sdk-latest\MIMXRT1180\multicore\rpmsg-lite\lib\include\environment\rtthread; packages\nxp-imxrt-sdk-latest\MIMXRT1180\multicore\rpmsg-lite\lib\include\platform\imxrt1180; ..\..\..\..\..\..\components\net\utest
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: template.srec
  ILINK.IlinkOutputFile: rtthread.out
  ILINK.IlinkConfigDefines: __use_shmem__=1; __multicore__=1
  ILINK.IlinkIcfFile: board\linker_scripts\MIMXRT1189xxxxx_cm7_ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration rtthread_hyperram (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: C:\0.RanChen\2.Projects\RT-Thread\rt-thread_pr\rt-thread\bsp\nxp\imx\imxrt\imxrt1180-nxp-evk\cm7\board\linker_scripts\MIMXRT1189xxxxx_cm7_hyperram.icf
configuration rtthread_flexspi_nor (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: C:\0.RanChen\2.Projects\RT-Thread\rt-thread_pr\rt-thread\bsp\nxp\imx\imxrt\imxrt1180-nxp-evk\cm7\board\linker_scripts\MIMXRT1189xxxxx_cm7_flexspi_nor.icf
configuration rtthread_flexspi_nor_hyperram (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: C:\0.RanChen\2.Projects\RT-Thread\rt-thread_pr\rt-thread\bsp\nxp\imx\imxrt\imxrt1180-nxp-evk\cm7\board\linker_scripts\MIMXRT1189xxxxx_cm7_flexspi_nor_hyperram.icf
  group Applications
    applications/: main.c multicore_thread.c
  group CPU
    ../../../../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../../../../libcpu/arm/cortex-m7/: context_iar.S cpu_cache.c cpuport.c
  group DeviceDrivers
    ../../../../../../components/drivers/core/: device.c
    ../../../../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../../../components/drivers/pin/: dev_pin.c
    ../../../../../../components/drivers/serial/: dev_serial.c
  group Drivers
    board/MCUX_Config/: clock_config.c pin_mux.c
    board/: board.c
    ../../libraries/drivers/: drv_common.c drv_gpio.c drv_uart.c
  group Finsh
    ../../../../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../../../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group Libc
    ../../../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../../../../components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
    ../../../../../../src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
  group Libraries
    packages/nxp-imxrt-sdk-latest/MIMXRT1180/MIMXRT1189/drivers/: fsl_common.c fsl_common_arm.c fsl_dcdc.c fsl_pmu.c fsl_clock.c fsl_ele_base_api.c fsl_s3mu.c fsl_trdc.c fsl_gpc.c fsl_memory.c fsl_soc_src.c fsl_edma.c fsl_edma_soc.c fsl_rgpio.c fsl_lpuart.c fsl_lpuart_edma.c fsl_mu.c
    packages/nxp-imxrt-sdk-latest/MIMXRT1180/MIMXRT1189/: system_MIMXRT1189_cm7.c
    packages/nxp-imxrt-sdk-latest/MIMXRT1180/MIMXRT1189/drivers/cm7/: fsl_cache.c
    packages/nxp-imxrt-sdk-latest/MIMXRT1180/MIMXRT1189/iar/: startup_MIMXRT1189_cm7.s
  group MultiCore
    packages/nxp-imxrt-sdk-latest/MIMXRT1180/multicore/mcmgr/src/: mcmgr.c mcmgr_internal_core_api_imxrt1180.c mcmgr_mu_internal.c
    packages/nxp-imxrt-sdk-latest/MIMXRT1180/multicore/rpmsg-lite/lib/common/: llist.c
    packages/nxp-imxrt-sdk-latest/MIMXRT1180/multicore/rpmsg-lite/lib/rpmsg_lite/: rpmsg_lite.c rpmsg_queue.c rpmsg_ns.c
    packages/nxp-imxrt-sdk-latest/MIMXRT1180/multicore/rpmsg-lite/lib/virtio/: virtqueue.c
    packages/nxp-imxrt-sdk-latest/MIMXRT1180/multicore/rpmsg-lite/lib/rpmsg_lite/porting/environment/: rpmsg_env_rtthread.c
    packages/nxp-imxrt-sdk-latest/MIMXRT1180/multicore/rpmsg-lite/lib/rpmsg_lite/porting/platform/imxrt1180/: rpmsg_platform.c
