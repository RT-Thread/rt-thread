# IAR project project.ewp, settings and files
configuration rtthread (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1052xxx5B NXP MIMXRT1052xxx5B
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: CPU_MIMXRT1064DVL6A; STD=C99; SKIP_SYSCLK_INIT; EVK_MCIMXRM; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; RT_USING_DLIBC
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: board\MCUX_Config; ..\..\..\..\..\..\NXP\RTT_BSP\imxrt_bsp\components\libc\compilers\common; ..\..\..\..\..\..\NXP\RTT_BSP\imxrt_bsp\libcpu\arm\cortex-m7; ..\Libraries\MIMXRT1064\MIMXRT1064\drivers; ..\Libraries\MIMXRT1064\MIMXRT1064; board\ports; ..\Libraries\drivers; ..\Libraries\drivers\config; ..\Libraries\MIMXRT1064\MIMXRT1064\iar; ..\..\..\..\..\..\NXP\RTT_BSP\imxrt_bsp\components\finsh; .; xip; applications; ..\..\..\..\..\..\NXP\RTT_BSP\imxrt_bsp\components\libc\compilers\dlib; board; ..\Libraries\MIMXRT1064\CMSIS\Include; ..\..\..\..\..\..\NXP\RTT_BSP\imxrt_bsp\include; ..\..\..\..\..\..\NXP\RTT_BSP\imxrt_bsp\libcpu\arm\common; ..\..\..\..\..\..\NXP\RTT_BSP\imxrt_bsp\components\drivers\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: template.srec
  ILINK.IlinkOutputFile: rtthread.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Kernel
    ../../../../../../NXP/RTT_BSP/imxrt_bsp/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group Applications
    applications/: main.c
  group Drivers
    board/: board.c
    board/MCUX_Config/: clock_config.c pin_mux.c
    ../Libraries/drivers/: drv_gpio.c drv_uart.c
  group xip
    xip/: evkmimxrt1064_flexspi_nor_config.c evkmimxrt1064_sdram_ini_dcd.c fsl_flexspi_nor_boot.c
  group cpu
    ../../../../../../NXP/RTT_BSP/imxrt_bsp/libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../../../../../NXP/RTT_BSP/imxrt_bsp/libcpu/arm/cortex-m7/: cpuport.c context_iar.S
  group DeviceDrivers
    ../../../../../../NXP/RTT_BSP/imxrt_bsp/components/drivers/clock_time/: clock_time_core.c
    ../../../../../../NXP/RTT_BSP/imxrt_bsp/components/drivers/misc/: pin.c
    ../../../../../../NXP/RTT_BSP/imxrt_bsp/components/drivers/serial/: serial.c
    ../../../../../../NXP/RTT_BSP/imxrt_bsp/components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
  group finsh
    ../../../../../../NXP/RTT_BSP/imxrt_bsp/components/finsh/: shell.c symbol.c cmd.c msh.c msh_cmd.c msh_file.c
  group libc
    ../../../../../../NXP/RTT_BSP/imxrt_bsp/components/libc/compilers/common/: gmtime_r.c
  group dlib
    ../../../../../../NXP/RTT_BSP/imxrt_bsp/components/libc/compilers/dlib/: environ.c libc.c rmtx.c stdio.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c time.c
  group Libraries
    ../Libraries/MIMXRT1064/MIMXRT1064/: system_MIMXRT1064.c
    ../Libraries/MIMXRT1064/MIMXRT1064/drivers/: fsl_common.c fsl_clock.c fsl_cache.c fsl_gpio.c fsl_lpuart.c
    ../Libraries/MIMXRT1064/MIMXRT1064/iar/: startup_MIMXRT1064.s
