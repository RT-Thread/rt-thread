# IAR project sd_mmc_example2_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMD20J18 Atmel ATSAMD20J18
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CYCLE_MODE; BOARD=SAMD20_XPLAINED_PRO; __SAMD20J18__; RTC_CALENDAR_ASYNC=false; SD_MMC_ENABLE; ARM_MATH_CM0PLUS=true; USART_CALLBACK_MODE=true; SPI_CALLBACK_MODE=true
  ICCARM.CCIncludePath2: ../../../../../../../sam0/drivers/system/clock/clock_samd20; ../../../../../../../sam0/drivers/system/power; ../../../../../../../sam0/drivers/system/reset; ../../../../../../../sam0/utils/preprocessor; ../../../../../../../thirdparty/fatfs/fatfs-r0.09/src; ../../../../../../../sam0/utils/cmsis/samd20/source; ../../../../../../services/delay; ../../../../../../../sam0/drivers/sercom/spi; ../../../../../../../sam0/utils; ../../../../../../../sam0/drivers/sercom; ../../../../../../../sam0/drivers/port; ../../../../../../../sam0/boards; ../../../../../../../sam0/drivers/sercom/usart; ../../../../../../../common/services/serial; ../../../../../../../sam0/drivers/rtc; ../../../../../../../common/utils; ../../../../../../../sam0/drivers/system/interrupt/system_interrupt_samd20; ../../../../../../../sam0/drivers/system/interrupt; ../../../../../../../sam0/drivers/system/reset/reset_sam_d_r_h; ../../../../../../services/delay/sam0; ../../../../../../../thirdparty/fatfs/fatfs-port-r0.09/sam0; ../../../../../../../sam0/drivers/system/power/power_sam_d_r_h; ../../../../../../../common/boards; ../../../../../../../sam0/utils/cmsis/samd20/include; ../../../../../../../sam0/drivers/system/pinmux; ../../../../../../../sam0/drivers/system; ..; ../..; ../../../../../../../sam0/drivers/rtc/rtc_sam_d_r_h; ../../..; ../../../../../../../sam0/utils/header_files; ../../../../../../../sam0/boards/samd20_xplained_pro; ../../../../../../../sam0/utils/stdio/stdio_serial; ../../../../../../../common/services/storage/ctrl_access; ../../../../../../../sam0/drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: sd_mmc_example2_flash.bin
  ILINK.IlinkOutputFile: sd_mmc_example2_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../sam0/utils/linker_scripts/samd20/iar/samd20j18_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/utils
    ../../../../../../../sam0/utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/samd20/source
    ../../../../../../../sam0/utils/cmsis/samd20/source/: system_samd20.c system_samd20.h
  group sam0/utils/cmsis/samd20/source/iar
    ../../../../../../../sam0/utils/cmsis/samd20/source/iar/: startup_samd20.c
  group sam0/utils/cmsis/samd20/include
    ../../../../../../../sam0/utils/cmsis/samd20/include/: samd20e16.h samd20g17.h samd20g15.h samd20j18.h samd20e14.h samd20g18u.h samd20e18.h samd20g14.h samd20.h samd20g18.h samd20j14.h samd20g17u.h samd20j16.h samd20e17.h samd20j15.h samd20g16.h samd20j17.h samd20e15.h
  group sam0/utils/cmsis/samd20/include/component
    ../../../../../../../sam0/utils/cmsis/samd20/include/component/: port.h pac.h sysctrl.h ac.h sercom.h dsu.h evsys.h adc.h dac.h rtc.h tc.h gclk.h pm.h eic.h nvmctrl.h wdt.h
  group sam0/utils/cmsis/samd20/include/pio
    ../../../../../../../sam0/utils/cmsis/samd20/include/pio/: samd20e18.h samd20e15.h samd20j16.h samd20e17.h samd20g18.h samd20j15.h samd20g14.h samd20g17.h samd20g17u.h samd20j14.h samd20j18.h samd20g16.h samd20g18u.h samd20j17.h samd20e14.h samd20g15.h samd20e16.h
  group sam0/utils/cmsis/samd20/include/instance
    ../../../../../../../sam0/utils/cmsis/samd20/include/instance/: sysctrl.h sercom5.h pac1.h wdt.h sercom2.h sercom1.h sercom4.h sercom3.h gclk.h ac.h tc5.h nvmctrl.h tc1.h tc3.h eic.h dac.h sercom0.h evsys.h adc.h tc7.h tc4.h tc0.h tc2.h pm.h rtc.h pac0.h dsu.h pac2.h port.h tc6.h
  group sam0/utils/stdio
    ../../../../../../../sam0/utils/stdio/: read.c write.c
  group sam0/utils/stdio/stdio_serial
    ../../../../../../../sam0/utils/stdio/stdio_serial/: stdio_serial.h
  group sam0/utils/preprocessor
    ../../../../../../../sam0/utils/preprocessor/: mrecursion.h mrepeat.h tpaste.h preprocessor.h stringz.h
  group sam0/utils/header_files
    ../../../../../../../sam0/utils/header_files/: io.h
  group sam0/drivers/port
    ../../../../../../../sam0/drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../../../sam0/drivers/port/quick_start/: qs_port_basic.h
  group sam0/drivers/system
    ../../../../../../../sam0/drivers/system/: system.c system.h
  group sam0/drivers/system/clock
    ../../../../../../../sam0/drivers/system/clock/: clock.h gclk.h
  group sam0/drivers/system/clock/clock_samd20
    ../../../../../../../sam0/drivers/system/clock/clock_samd20/: clock.c gclk.c clock_feature.h clock_config_check.h
  group sam0/drivers/system/interrupt
    ../../../../../../../sam0/drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_samd20
    ../../../../../../../sam0/drivers/system/interrupt/system_interrupt_samd20/: system_interrupt_features.h
  group sam0/drivers/system/pinmux
    ../../../../../../../sam0/drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../../../sam0/drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/power/power_sam_d_r_h
    ../../../../../../../sam0/drivers/system/power/power_sam_d_r_h/: power.h
  group sam0/drivers/system/reset/reset_sam_d_r_h
    ../../../../../../../sam0/drivers/system/reset/reset_sam_d_r_h/: reset.h
  group sam0/drivers/sercom
    ../../../../../../../sam0/drivers/sercom/: sercom.c sercom_interrupt.c sercom_pinout.h sercom.h sercom_interrupt.h
  group sam0/drivers/sercom/usart
    ../../../../../../../sam0/drivers/sercom/usart/: usart.c usart_interrupt.c usart_interrupt.h usart.h
  group sam0/drivers/sercom/usart/quick_start_callback
    ../../../../../../../sam0/drivers/sercom/usart/quick_start_callback/: qs_usart_callback.h
  group sam0/drivers/sercom/usart/quick_start_dma
    ../../../../../../../sam0/drivers/sercom/usart/quick_start_dma/: qs_usart_dma_use.h
  group sam0/drivers/sercom/usart/quick_start_lin
    ../../../../../../../sam0/drivers/sercom/usart/quick_start_lin/: qs_lin.h
  group sam0/drivers/sercom/usart/quick_start
    ../../../../../../../sam0/drivers/sercom/usart/quick_start/: qs_usart_basic_use.h
  group sam0/drivers/sercom/spi
    ../../../../../../../sam0/drivers/sercom/spi/: spi.c spi_interrupt.c spi.h spi_interrupt.h
  group sam0/drivers/sercom/spi/quick_start_slave
    ../../../../../../../sam0/drivers/sercom/spi/quick_start_slave/: qs_spi_slave_basic.h
  group sam0/drivers/sercom/spi/quick_start_slave_callback
    ../../../../../../../sam0/drivers/sercom/spi/quick_start_slave_callback/: qs_spi_slave_callback.h
  group sam0/drivers/sercom/spi/quick_start_dma
    ../../../../../../../sam0/drivers/sercom/spi/quick_start_dma/: qs_spi_dma_use.h
  group sam0/drivers/sercom/spi/quick_start_master
    ../../../../../../../sam0/drivers/sercom/spi/quick_start_master/: qs_spi_master_basic.h
  group sam0/drivers/sercom/spi/quick_start_master_callback
    ../../../../../../../sam0/drivers/sercom/spi/quick_start_master_callback/: qs_spi_master_callback.h
  group sam0/drivers/rtc
    ../../../../../../../sam0/drivers/rtc/: rtc_tamper.h rtc_calendar.h
  group sam0/drivers/rtc/rtc_sam_d_r_h
    ../../../../../../../sam0/drivers/rtc/rtc_sam_d_r_h/: rtc_calendar.c
  group sam0/boards/samd20_xplained_pro
    ../../../../../../../sam0/boards/samd20_xplained_pro/: board_init.c samd20_xplained_pro.h
  group common2/components/memory/sd_mmc
    ../../../: sd_mmc_spi.c sd_mmc_mem.c sd_mmc.c sd_mmc.h sd_mmc_spi.h sd_mmc_protocol.h sd_mmc_mem.h
  group common2/components/memory/sd_mmc/example2
    ../../: example.c conf_fatfs.h conf_access.h
  group common2/components/memory/sd_mmc/example2/samd20j18_samd20_xplained_pro
    ../: conf_board.h conf_sd_mmc.h conf_sleepmgr.h conf_example.h conf_spi.h conf_clocks.h
  group common2/components/memory/sd_mmc/example2/samd20j18_samd20_xplained_pro/iar
    ./: asf.h
  group common2/services/delay
    ../../../../../../services/delay/: delay.h
  group common2/services/delay/sam0
    ../../../../../../services/delay/sam0/: cycle_counter.c cycle_counter.h
  group thirdparty/fatfs/fatfs-r0.09/src
    ../../../../../../../thirdparty/fatfs/fatfs-r0.09/src/: ff.c ff.h integer.h ffconf.h diskio.h
  group thirdparty/fatfs/fatfs-r0.09/src/option
    ../../../../../../../thirdparty/fatfs/fatfs-r0.09/src/option/: ccsbcs.c
  group thirdparty/fatfs/fatfs-port-r0.09
    ../../../../../../../thirdparty/fatfs/fatfs-port-r0.09/: diskio.c
  group thirdparty/fatfs/fatfs-port-r0.09/sam0
    ../../../../../../../thirdparty/fatfs/fatfs-port-r0.09/sam0/: fattime_rtc.c
  group common/services/storage/ctrl_access
    ../../../../../../../common/services/storage/ctrl_access/: ctrl_access.c ctrl_access.h
  group common/services/serial
    ../../../../../../../common/services/serial/: serial.h
  group common/services/serial/sam0_usart
    ../../../../../../../common/services/serial/sam0_usart/: usart_serial.h
  group common/utils
    ../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../../common/boards/: board.h
