<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/KsdkStartupLib_K64F12.ewp</path>
  </project>
</workspace>
