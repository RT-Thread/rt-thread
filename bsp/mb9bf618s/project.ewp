# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MB9BF618S Fujitsu MB9BF618S
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: MB9B610S; __RTTHREAD__
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\components\libc\compilers\common\nogcc; ..\..\include; drivers; ..\..\components\libc\compilers\common; .; applications; ..\..\examples\utest\testcases\kernel; ..\..\libcpu\arm\cortex-m3; CMSIS\Include; ..\..\libcpu\arm\common; CMSIS\DeviceSupport\fujitsu\mb9bf61x; ..\..\components\finsh
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: rtthread-fm3.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; MB9B610S; __RTTHREAD__
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: template.out
  group Applications
    applications/: application.c startup.c
  group CMSIS
    CMSIS/DeviceSupport/fujitsu/mb9bf61x/: system_mb9bf61x.c
    CMSIS/DeviceSupport/fujitsu/mb9bf61x/startup/iar/: startup_mb9bf61x.S
  group CPU
    ../../libcpu/arm/common/: backtrace.c showmem.c div0.c
    ../../libcpu/arm/cortex-m3/: cpuport.c context_iar.S
  group Drivers
    drivers/: board.c led.c serial.c
  group Finsh
    ../../components/finsh/: shell.c msh.c
  group Kernel
    ../../src/: components.c timer.c kservice.c object.c mempool.c thread.c device.c irq.c idle.c clock.c mem.c ipc.c scheduler.c
