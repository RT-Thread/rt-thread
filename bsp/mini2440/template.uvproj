# Keil uVision project template.uvproj, settings and files
target RT-Thread Mini2440 (ARM-ADS)
  device: S3C2440A Samsung
  cpu: IRAM(0x40000000-0x40000FFF) CLOCK(12000000) CPUTYPE(ARM920T)
  output: rtthread-mini2440
  c flags: Optim=1
  c misc: --diag_suppress=870
  memory RVCT9: RAM 0x40000000 size 0x1000
  scatter file: rtthread-mini2440.sct
