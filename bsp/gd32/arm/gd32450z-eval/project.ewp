# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: GD32F450xK GD GD32F450xK
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32F4XX; CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; _DLIB_FILE_DESCRIPTOR; GD32F450; __RTTHREAD__; USE_STDPERIPH_DRIVER; __RT_IPC_SOURCE__; __RT_KERNEL_SOURCE__
  ICCARM.CCIncludePath2: ..\..\..\..\components\libc\posix\io\poll; ..\..\..\..\include; ..\..\..\..\components\libc\posix\io\epoll; board; ..\..\..\..\libcpu\arm\cortex-m4; ..\..\..\..\components\libc\compilers\common\extension\fcntl\octal; ..\..\..\..\components\libc\compilers\common\include; ..\..\..\..\components\libc\posix\io\eventfd; ..\..\..\..\components\libc\compilers\common\extension; ..\libraries\GD32F4xx_Firmware_Library\GD32F4xx_standard_peripheral\Include; applications; ..\..\..\..\components\drivers\include; ..\..\..\..\components\drivers\smp_call; ..\..\..\..\components\finsh; .; ..\..\..\..\components\drivers\phy; ..\..\..\..\components\dfs\dfs_v1\include; ..\..\..\..\libcpu\arm\common; ..\libraries\gd32_drivers; ..\libraries\GD32F4xx_Firmware_Library\CMSIS; ..\..\..\..\components\libc\posix\ipc; ..\libraries\GD32F4xx_Firmware_Library\CMSIS\GD\GD32F4xx\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: project.srec
  ILINK.IlinkOutputFile: rtthread.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; _DLIB_FILE_DESCRIPTOR; GD32F450; __RTTHREAD__; USE_STDPERIPH_DRIVER; __RT_IPC_SOURCE__; __RT_KERNEL_SOURCE__
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: main.c
  group Compiler
    ../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../../components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
  group DeviceDrivers
    ../../../../components/drivers/core/: device.c
    ../../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../components/drivers/pin/: dev_pin.c
    ../../../../components/drivers/serial/: dev_serial.c
  group Drivers
    board/: board.c
    ../libraries/GD32F4xx_Firmware_Library/CMSIS/GD/GD32F4xx/Source/IAR/: startup_gd32f4xx.s
    ../libraries/gd32_drivers/: drv_gpio.c drv_usart.c
  group Filesystem
    ../../../../components/dfs/dfs_v1/src/: dfs_file.c dfs.c dfs_posix.c dfs_fs.c
  group Finsh
    ../../../../components/finsh/: msh.c cmd.c msh_parse.c shell.c msh_file.c
  group Kernel
    ../../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    ../../../../src/klibc/: rt_vsnprintf_tiny.c kstring.c rt_vsscanf.c kerrno.c kstdio.c
  group libcpu
    ../../../../libcpu/arm/common/: div0.c showmem.c
    ../../../../libcpu/arm/cortex-m4/: context_iar.S cpuport.c
  group Libraries
    ../libraries/GD32F4xx_Firmware_Library/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
    ../libraries/GD32F4xx_Firmware_Library/GD32F4xx_standard_peripheral/Source/: gd32f4xx_gpio.c gd32f4xx_rcu.c gd32f4xx_syscfg.c gd32f4xx_dma.c gd32f4xx_exti.c gd32f4xx_misc.c gd32f4xx_usart.c
