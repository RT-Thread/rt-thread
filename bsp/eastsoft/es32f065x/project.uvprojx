# Keil uVision project project.uvprojx, settings and files
target rt-thread_es32f065x (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: ES32F0654LT Eastsoft
  pack: Eastsoft.ES32_DFP.1.0.1
  cpu: IRAM(0x20000000,0x00008000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: rtthread-es32f065x +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c include: .;..\..\..\include;applications;.;..\..\..\libcpu\arm\common;..\..\..\libcpu\arm\cortex-m0;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\finsh;..\libraries\ES32F065x_ALD\CMSIS\Device\EastSoft\ES32F065x\Include;..\libraries\ES32F065x_ALD\CMSIS\Include;..\libraries\ES32F065x_ALD\ES32F065x_ALD_StdPeriph_Driver\Include;..\libraries\ALD_Drivers
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --keep *.o(.rti_fn.*)   --keep *.o(FSymTab)
  group Kernel
    ../../../src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group Applications
    applications/: main.c
  group cpu
    ../../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m0/: cpuport.c context_rvds.S
  group DeviceDrivers
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
  group finsh
    ../../../components/finsh/: shell.c symbol.c cmd.c msh.c msh_cmd.c msh_file.c
  group ES32F065x_StdPeriph
    ../libraries/ES32F065x_ALD/ES32F065x_ALD_StdPeriph_Driver/Source/: ald_acmp.c ald_adc.c ald_bkpc.c ald_calc.c ald_can.c ald_cmu.c ald_crc.c ald_crypt.c ald_dma.c ald_flash.c ald_gpio.c ald_i2c.c ald_iap.c ald_pis.c ald_pmu.c ald_rmu.c ald_rtc.c ald_smartcard.c ald_spi.c ald_temp.c ald_timer.c ald_trng.c ald_uart.c ald_usart.c ald_wdt.c utils.c
    ../libraries/ES32F065x_ALD/CMSIS/Device/EastSoft/ES32F065x/Startup/keil/: startup_es32f065x.s
  group Drivers
    ../libraries/ALD_Drivers/: board.c drv_gpio.c drv_usart.c
