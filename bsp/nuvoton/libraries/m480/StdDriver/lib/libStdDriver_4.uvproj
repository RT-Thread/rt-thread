# Keil uVision project libStdDriver_4.uvproj, settings and files
target libStdDriver_4 (ARM-ADS)
  device: M487JIDAE Nuvoton
  cpu: IRAM(0x20000000-0x20027FFF) IROM(0-0x7FFFF) CLOCK(192000000) CPUTYPE("Cortex-M4") FPU2
  output: libstddriver_keil4 +hex (library)
  AfterMake: xcopy /y ".\build\keil4\@L.lib" "."
  c flags: Optim=1
  c misc: --c99
  c include: ..\lib;..\inc;..\..\CMSIS\Include;..\..\Device\Nuvoton\M480\Include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  scatter file: .\linking_scripts\m480_flash.sct
  group src
    ../src/: nu_acmp.c nu_bpwm.c nu_can.c nu_ccap.c nu_clk.c nu_crc.c nu_crypto.c nu_dac.c nu_eadc.c nu_ebi.c nu_ecap.c nu_emac.c nu_epwm.c nu_fmc.c nu_gpio.c nu_hsusbd.c nu_i2c.c nu_i2s.c nu_pdma.c nu_qei.c nu_qspi.c nu_rtc.c nu_sc.c nu_scuart.c nu_sdh.c nu_spi.c nu_spim.c nu_sys.c nu_timer.c nu_timer_pwm.c nu_trng.c nu_uart.c nu_usbd.c nu_usci_i2c.c nu_usci_spi.c nu_usci_uart.c nu_wdt.c nu_wwdt.c
