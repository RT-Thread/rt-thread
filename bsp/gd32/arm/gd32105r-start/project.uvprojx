# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: GD32F105RC GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.1
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(25000000) ELITTLE
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=4 uC99=1 v6Lang=1 v6LangP=1
  c define: RT_USING_LIBC, __RTTHREAD__, __STDC_LIMIT_MACROS, USE_STDPERIPH_DRIVER, __CLK_TCK=RT_TICK_PER_SECOND, RT_USING_ARMLIBC, GD32F10X_CL
  c include: ..\..\..\..\components\libc\posix\io\eventfd;..\..\..\..\components\libc\posix\io\poll;..\libraries\gd32_drivers;..\..\..\..\libcpu\arm\common;..\libraries\GD32F10x_Firmware_Library\CMSIS;..\..\..\..\components\drivers\smp_call;..\..\..\..\components\libc\posix\ipc;applications;..\..\..\..\components\finsh;..\..\..\..\libcpu\arm\cortex-m3;..\..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\..\components\drivers\include;.;..\..\..\..\components\libc\posix\io\epoll;..\..\..\..\components\drivers\include;..\..\..\..\components\drivers\include;..\..\..\..\include;..\..\..\..\components\libc\compilers\common\include;..\..\..\..\components\drivers\include;..\libraries\GD32F10x_Firmware_Library\CMSIS\GD\GD32F10x\Include;..\libraries\GD32F10x_Firmware_Library\GD32F10x_standard_peripheral\Include;..\..\..\..\components\drivers\phy;..\..\..\..\components\drivers\include;board;..\..\..\..\components\libc\compilers\common\extension
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Applications
    applications/: main.c
  group Compiler
    ../../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../../components/drivers/core/: device.c
    ../../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../components/drivers/pin/: dev_pin.c
    ../../../../components/drivers/serial/: dev_serial.c
  group Drivers
    board/: board.c
    ../libraries/GD32F10x_Firmware_Library/CMSIS/GD/GD32F10x/Source/ARM/: startup_gd32f10x_cl.s
    ../libraries/gd32_drivers/: drv_gpio.c drv_usart.c
  group Finsh
    ../../../../components/finsh/: cmd.c msh.c msh_parse.c shell.c
  group Kernel
    ../../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    ../../../../src/klibc/: kerrno.c rt_vsnprintf_tiny.c rt_vsscanf.c kstring.c kstdio.c
  group libcpu
    ../../../../libcpu/arm/common/: div0.c showmem.c
    ../../../../libcpu/arm/cortex-m3/: context_rvds.S cpuport.c
  group Libraries
    ../libraries/GD32F10x_Firmware_Library/CMSIS/GD/GD32F10x/Source/: system_gd32f10x.c
    ../libraries/GD32F10x_Firmware_Library/GD32F10x_standard_peripheral/Source/: gd32f10x_gpio.c gd32f10x_usart.c gd32f10x_exti.c gd32f10x_misc.c gd32f10x_rcu.c
software components: CMSIS:CORE 5.4.0
