# IAR project project.ewp, settings and files
configuration rtthread (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1052xxx5B NXP MIMXRT1052xxx5B
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: CPU_MIMXRT1064DVL6A; SKIP_SYSCLK_INIT; EVK_MCIMXRM; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=1; __RTTHREAD__; RT_USING_DLIBC
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: board\MCUX_Config; ..\..\..\components\finsh; ..\..\..\libcpu\arm\common; ..\libraries\MIMXRT1064\MIMXRT1064\drivers; ..\..\..\libcpu\arm\cortex-m7; board\ports; ..\libraries\drivers; ..\libraries\drivers\config; ..\..\..\components\drivers\include; ..\libraries\MIMXRT1064\MIMXRT1064; ..\..\..\examples\utest\testcases\kernel; .; xip; applications; ..\..\..\components\libc\compilers\dlib; board; ..\..\..\components\libc\compilers\common; ..\libraries\peripherals; ..\libraries\MIMXRT1064\CMSIS\Include; ..\..\..\include; ..\..\..\components\libc\compilers\common\nogcc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: template.srec
  ILINK.IlinkOutputFile: rtthread.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Applications
    applications/: main.c
  group CPU
    ../../../libcpu/arm/common/: div0.c showmem.c backtrace.c
    ../../../libcpu/arm/cortex-m7/: context_iar.S cpu_cache.c cpuport.c
  group DeviceDrivers
    ../../../components/drivers/cputime/: cputime.c
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/src/: waitqueue.c pipe.c ringblk_buf.c dataqueue.c ringbuffer.c workqueue.c completion.c
  group Drivers
    board/MCUX_Config/: pin_mux.c clock_config.c
    board/: board.c
    ../libraries/drivers/: drv_gpio.c drv_uart.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c cmd.c
  group Kernel
    ../../../src/: scheduler.c ipc.c components.c timer.c object.c irq.c thread.c clock.c device.c idle.c mempool.c memheap.c kservice.c
  group libc
    ../../../components/libc/compilers/common/: stdlib.c time.c
    ../../../components/libc/compilers/dlib/: environ.c syscall_write.c syscall_lseek.c syscall_read.c syscall_mem.c stdio.c syscall_remove.c syscall_open.c libc.c syscalls.c syscall_close.c
  group Libraries
    ../libraries/MIMXRT1064/MIMXRT1064/drivers/: fsl_clock.c fsl_gpio.c fsl_cache.c fsl_lpuart.c fsl_common.c
    ../libraries/MIMXRT1064/MIMXRT1064/iar/: startup_MIMXRT1064.s
    ../libraries/MIMXRT1064/MIMXRT1064/: system_MIMXRT1064.c
  group xip
    xip/: evkmimxrt1064_sdram_ini_dcd.c evkmimxrt1064_flexspi_nor_config.c fsl_flexspi_nor_boot.c
