# IAR project project.ewp, settings and files
configuration rt-thread (ARM, debug)
  General.OGChipSelectEditMenu: STM32MP157A_M4 ST STM32MP157A_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: CORE_CM4; NO_ATOMIC_64_SUPPORT; METAL_INTERNAL; METAL_MAX_DEVICE_REGIONS=2; VIRTIO_SLAVE_ONLY; STM32MP157Axx; __LOG_TRACE_IO_; __RTTHREAD__; __RT_KERNEL_SOURCE__
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: applications; ..\..\..\libcpu\arm\common; ..\..\..\libcpu\arm\cortex-m4; ..\..\..\components\drivers\phy; ..\..\..\components\drivers\include; ..\..\..\components\drivers\smp_call; board; board\CubeMX_Config\CM4\Inc; board\ports; ..\libraries\HAL_Drivers\nano; ..\libraries\HAL_Drivers; ..\..\..\components\finsh; .; ..\..\..\include; ..\..\..\components\net\utest
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: template.bin
  ILINK.IlinkOutputFile: RT-Thread-STM32MP1_CM4.elf
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: main.c
  group CPU
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m4/: context_iar.S cpuport.c
  group Drivers
    ../libraries/HAL_Drivers/: drv_common.c
    ../libraries/HAL_Drivers/nano/: drv_console.c drv_gpio.c
    board/CubeMX_Config/CM4/Src/: stm32mp1xx_hal_msp.c
    board/: board.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group Libc
    ../../../src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
