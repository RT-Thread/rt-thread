# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32L436RB Nationstech
  pack: Nationstech.N32L43x_DFP.0.1.0
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rtthread +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __STDC_LIMIT_MACROS, __CLK_TCK=RT_TICK_PER_SECOND, N32L43X, __RTTHREAD__, RT_USING_LIBC, RT_USING_ARMLIBC, USE_STDPERIPH_DRIVER
  c include: ..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\libc\compilers\common\include;..\..\..\components\libc\posix\io\epoll;..\..\..\components\drivers\smp_call;..\..\..\components\libc\posix\ipc;..\..\..\libcpu\arm\common;..\..\..\components\drivers\include;..\..\..\components\drivers\include;.;..\libraries\N32L43x_Firmware_Library\n32l43x_std_periph_driver\inc;..\..\..\components\libc\posix\io\eventfd;..\..\..\components\drivers\include;..\..\..\components\net\utest;..\libraries\n32_drivers\config;..\libraries\n32_drivers;..\libraries\N32L43x_Firmware_Library\CMSIS\device;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;applications;..\libraries\N32L43x_Firmware_Library\CMSIS\core;..\..\..\components\drivers\spi;board;..\..\..\components\libc\posix\io\poll;..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\components\drivers\phy;..\..\..\libcpu\arm\cortex-m4;..\..\..\components\libc\compilers\common\extension;..\..\..\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\finsh;..\..\..\components\drivers\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group CPU
    ../../../libcpu/arm/common/: div0.c showmem.c
    ../../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../../components/drivers/can/: dev_can.c
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/clock_time/: clock_timer.c
    ../../../components/drivers/i2c/: dev_i2c_bit_ops.c dev_i2c_core.c dev_i2c_dev.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/misc/: adc.c dac.c rt_drv_pwm.c
    ../../../components/drivers/pin/: dev_pin.c
    ../../../components/drivers/rtc/: dev_rtc.c
    ../../../components/drivers/serial/: dev_serial.c
    ../../../components/drivers/spi/: dev_spi.c dev_spi_core.c
    ../../../components/drivers/watchdog/: dev_watchdog.c
  group Drivers
    ../libraries/N32L43x_Firmware_Library/CMSIS/device/startup/: startup_n32l43x.s
    board/: board.c
    ../libraries/n32_drivers/: drv_adc.c drv_base.c drv_can.c drv_dac.c drv_gpio.c drv_timer.c drv_pwm.c drv_rtc.c drv_spi.c drv_usart.c drv_wdt.c
  group Finsh
    ../../../components/finsh/: msh_parse.c cmd.c shell.c msh.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group Libc
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
  group Libraries
    ../libraries/N32L43x_Firmware_Library/n32l43x_std_periph_driver/src/: n32l43x_adc.c n32l43x_can.c n32l43x_usart.c n32l43x_i2c.c n32l43x_spi.c n32l43x_gpio.c n32l43x_pwr.c n32l43x_iwdg.c n32l43x_wwdg.c n32l43x_tim.c n32l43x_flash.c n32l43x_rtc.c n32l43x_rcc.c n32l43x_exti.c n32l43x_dac.c misc.c
    ../libraries/N32L43x_Firmware_Library/CMSIS/device/: system_n32l43x.c
software components: CMSIS:CORE 5.4.0
