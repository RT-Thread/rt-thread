# Keil uVision project project.uvprojx, settings and files
target rtthread (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: MM32F103RBT MindMotion
  pack: MindMotion.MM32F103x8xB_DFP.1.4.7
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rtthread +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: RT_USING_ARMLIBC, __CLK_TCK=RT_TICK_PER_SECOND, __RTTHREAD__, USE_STDPERIPH_DRIVER, RT_USING_LIBC, __STDC_LIMIT_MACROS
  c include: ..\..\components\libc\posix\io\epoll;..\..\components\drivers\include;drivers;..\..\components\libc\compilers\common\extension;..\..\components\drivers\phy;..\..\include;Libraries\CMSIS\KEIL_CORE;..\..\components\drivers\include;Libraries\MM32F103\HAL_lib\inc;..\..\components\libc\compilers\common\include;..\..\components\libc\posix\io\poll;.;..\..\components\drivers\include;..\..\components\libc\posix\io\eventfd;..\..\components\net\utest;..\..\components\finsh;..\..\components\drivers\smp_call;Libraries\MM32F103\Source;..\..\components\drivers\include;Libraries\MM32F103\Include;..\..\libcpu\arm\cortex-m3;..\..\components\libc\posix\ipc;..\..\components\drivers\include;applications;..\..\libcpu\arm\common;..\..\components\drivers\include;..\..\components\libc\compilers\common\extension\fcntl\octal
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\drivers\linker_scripts\link.sct
  group CPU
    ../../libcpu/arm/common/: div0.c showmem.c
    ../../libcpu/arm/cortex-m3/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../components/drivers/core/: device.c
    ../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../components/drivers/pin/: dev_pin.c
    ../../components/drivers/serial/: dev_serial.c
  group Drivers
    drivers/: board.c drv_uart.c drv_gpio.c
  group Finsh
    ../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group Libc
    ../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
  group Libraries
    Libraries/MM32F103/Source/: system_MM32F103.c
    Libraries/MM32F103/HAL_lib/src/: HAL_adc.c HAL_bkp.c HAL_can.c HAL_crc.c HAL_dma.c HAL_exti.c HAL_flash.c HAL_gpio.c HAL_i2c.c HAL_iwdg.c HAL_misc.c HAL_pwr.c HAL_rcc.c HAL_rtc.c HAL_spi.c HAL_tim.c HAL_uart.c HAL_wwdg.c
    Libraries/MM32F103/Source/KEIL_StartAsm/: startup_MM32F103.s
