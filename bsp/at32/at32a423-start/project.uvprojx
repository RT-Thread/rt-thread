# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: AT32A423VCT7 ArteryTek
  pack: ArteryTek.AT32A423_DFP.2.0.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __STDC_LIMIT_MACROS, RT_USING_ARMLIBC, USE_STDPERIPH_DRIVER, RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND, AT32A423VCT7, __RTTHREAD__
  c include: ..\..\..\include;..\libraries\rt_drivers\config;..\..\..\components\libc\compilers\common\include;..\..\..\components\drivers\include;..\libraries\rt_drivers;..\..\..\components\libc\compilers\common\extension;..\..\..\components\libc\posix\io\poll;applications;board\inc;..\..\..\libcpu\arm\common;board;..\libraries\AT32A423_Firmware_Library\drivers\inc;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\components\finsh;.;..\..\..\components\libc\posix\ipc;..\libraries\usbotg_library\inc;..\libraries\AT32A423_Firmware_Library\cmsis\cm4\device_support;..\libraries\AT32A423_Firmware_Library\cmsis\cm4\core_support;..\..\..\components\drivers\include;..\..\..\libcpu\arm\cortex-m4;..\..\..\components\libc\posix\io\eventfd;..\..\..\components\libc\posix\io\epoll
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/ipc/: completion.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/pin/: pin.c
    ../../../components/drivers/serial/: serial.c
  group Drivers
    board/src/: at32_msp.c board.c
    ../libraries/AT32A423_Firmware_Library/cmsis/cm4/device_support/startup/mdk/: startup_at32a423.s
    ../libraries/rt_drivers/: drv_common.c drv_gpio.c drv_usart.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../../src/: clock.c components.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
    ../../../src/klibc/: kstdio.c kstring.c
  group libcpu
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group Libraries
    ../libraries/AT32A423_Firmware_Library/cmsis/cm4/device_support/: system_at32a423.c
    ../libraries/AT32A423_Firmware_Library/drivers/src/: at32a423_exint.c at32a423_debug.c at32a423_acc.c at32a423_spi.c at32a423_i2c.c at32a423_usart.c at32a423_xmc.c at32a423_dac.c at32a423_adc.c at32a423_tmr.c at32a423_crc.c at32a423_crm.c at32a423_ertc.c at32a423_pwc.c at32a423_dma.c at32a423_can.c at32a423_misc.c at32a423_flash.c at32a423_wwdt.c at32a423_usb.c at32a423_wdt.c at32a423_scfg.c at32a423_gpio.c
