# Keil uVision project project.uvprojx, settings and files
target rtthread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MIMXRT1052:M7 NXP
  pack: NXP.iMXRT_DFP.1.0.3
  cpu: IRAM(0x20000000,0x00060000) IRAM2(0x00000000,0x00020000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: __RTTHREAD__, FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1, XIP_EXTERNAL_FLASH=1, RT_USING_LIBC, RT_USING_ARMLIBC, __STDC_LIMIT_MACROS, __CLK_TCK=RT_TICK_PER_SECOND, EVK_MCIMXRM, CPU_MIMXRT1052DVL6B, SKIP_SYSCLK_INIT
  c misc: --library_interface=armcc --library_type=standardlib --diag_suppress=66,1296,186
  c include: ..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\drivers\include;..\libraries\drivers;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\libc\posix\ipc;board;applications;board\ports;..\..\..\..\..\components\libc\compilers\common\include;xip;..\..\..\..\..\libcpu\arm\common;..\..\..\..\..\components\libc\posix\io\poll;..\..\..\..\..\components\finsh;..\libraries\MIMXRT1050\MIMXRT1052;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\libc\compilers\common\extension;board\MCUX_Config;..\..\..\..\..\components\drivers\smp_call;..\..\..\..\..\components\libc\posix\io\eventfd;..\..\..\..\..\include;..\..\..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\libraries\MIMXRT1050\MIMXRT1052\drivers;..\..\..\..\..\components\libc\posix\io\epoll;..\..\..\..\..\libcpu\arm\cortex-m7;..\..\..\..\..\components\net\netdev\include;.;..\..\..\..\..\components\drivers\phy;..\libraries\MIMXRT1050\CMSIS\Include
  memory RVCT9: RAM 0x20000000 size 0x60000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\board\linker_scripts\link.sct
  link misc: --keep=*(.boot_hdr.ivt)--keep=*(.boot_hdr.boot_data)--keep=*(.boot_hdr.dcd_data)--keep=*(.boot_hdr.conf)
  group Applications
    applications/: mnt.c main.c
  group Compiler
    ../../../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../../../components/drivers/core/: device.c
    ../../../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../../components/drivers/phy/: phy.c
    ../../../../../components/drivers/pin/: dev_pin.c
    ../../../../../components/drivers/serial/: dev_serial.c
  group Drivers
    board/MCUX_Config/: clock_config.c pin_mux.c
    board/: board.c
    ../libraries/drivers/: drv_common.c drv_gpio.c drv_uart.c
  group Finsh
    ../../../../../components/finsh/: msh.c cmd.c msh_parse.c shell.c
  group Kernel
    ../../../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    ../../../../../src/klibc/: rt_vsscanf.c rt_vsnprintf_tiny.c kstdio.c kerrno.c kstring.c
  group libcpu
    ../../../../../libcpu/arm/common/: div0.c showmem.c
    ../../../../../libcpu/arm/cortex-m7/: context_rvds.S cpu_cache.c cpuport.c
  group Libraries
    ../libraries/MIMXRT1050/MIMXRT1052/drivers/: fsl_cache.c fsl_xbara.c fsl_clock.c fsl_xbarb.c fsl_lpuart.c generic_list.c fsl_gpio.c fsl_common.c fsl_os_abstraction_rtthread.c
    ../libraries/MIMXRT1050/MIMXRT1052/arm/: startup_MIMXRT1052.s
    ../libraries/MIMXRT1050/MIMXRT1052/: system_MIMXRT1052.c
  group SAL
    ../../../../../components/net/netdev/src/: netdev_ipaddr.c netdev.c
  group xip
    xip/: fsl_flexspi_nor_flash.c fsl_flexspi_nor_boot.c
software components: CMSIS:CORE 5.0.2
