# Keil uVision project project.uvprojx, settings and files
target rt-thread (ARM-ADS)
  device: ES32F0271LT Eastsoft
  pack: Eastsoft.ES32_DFP.1.0.4
  cpu: IRAM(0x20000000,0x00002000) IROM(0x00000000,0x00010000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND
  c include: applications;.;..\..\..\libcpu\arm\common;..\..\..\libcpu\arm\cortex-m0;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;drivers;..\..\..\components\finsh;.;..\..\..\include;..\..\..\components\libc\compilers\common;..\..\..\components\libc\compilers\common\nogcc;libraries\CMSIS\Device\EastSoft\ES32F0271\Include;libraries\CMSIS\Device\EastSoft\ES32F0271\Include\ES32F0271;libraries\CMSIS\Device\EastSoft\ES32F0271\System;libraries\CMSIS\Include;libraries;libraries\ES32F027x_MD_StdPeriph_Driver\Include;..\..\..\examples\utest\testcases\kernel
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Applications
    applications/: main.c
  group CPU
    ../../../libcpu/arm/common/: div0.c showmem.c backtrace.c
    ../../../libcpu/arm/cortex-m0/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/src/: dataqueue.c ringbuffer.c ringblk_buf.c pipe.c waitqueue.c completion.c workqueue.c
  group Drivers
    drivers/: drv_gpio.c drv_uart.c board.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c
  group Kernel
    ../../../src/: object.c scheduler.c clock.c timer.c idle.c mempool.c device.c components.c thread.c kservice.c ipc.c irq.c mem.c
  group Libraries
    libraries/ES32F027x_MD_StdPeriph_Driver/Source/: md_rcu.c md_usb.c md_fc.c md_uart.c md_gpio.c md_wwdt.c md_tick.c md_i2c.c md_spi.c md_adc.c
    libraries/CMSIS/Device/EastSoft/ES32F0271/System/: system_es32f027x.c
    libraries/CMSIS/Device/EastSoft/ES32F0271/Startup/keil/: startup_es32f027x.s
