# Keil uVision project project.uvproj, settings and files
target RT-Thread LPC2478 (ARM-ADS)
  device: LPC2478 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x4000FFFF) IRAM2(0x7FE00000-0x7FE03FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: rtthread-lpc
  c flags: Optim=1
  c define: __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND
  c include: applications;.;..\..\libcpu\arm\common;..\..\libcpu\arm\lpc24xx;drivers;..\..\components\finsh;.;..\..\include;..\..\components\libc\compilers\common;..\..\components\libc\compilers\common\nogcc;..\..\examples\utest\testcases\kernel
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x10000
  memory RVCT10: RAM 0x7fe00000 size 0x4000
  group Applications
    applications/: startup.c application.c
  group CPU
    ../../libcpu/arm/common/: div0.c backtrace.c showmem.c
    ../../libcpu/arm/lpc24xx/: trap.c start_rvds.S cpu.c stack.c interrupt.c context_rvds.S
  group Drivers
    drivers/: serial.c board.c
  group Finsh
    ../../components/finsh/: shell.c msh.c
  group Kernel
    ../../src/: timer.c device.c clock.c mempool.c ipc.c thread.c kservice.c idle.c mem.c scheduler.c irq.c components.c object.c
