# Keil uVision project project.uvprojx, settings and files
target RT-Thread LPC82x (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: LPC824M201JHI33 NXP
  pack: Keil.LPC800_DFP.1.5.0
  cpu: IRAM(0x10000000,0x00002000) IROM(0x00000000,0x00008000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: rtthread-lpc
  c flags: Optim=3 OneElfS=1 v6Lang=1 v6LangP=1
  c define: CORE_M0PLUS, __RTTHREAD__
  c include: Libraries\common\CMSIS;..\..\..\..\components\drivers\smp_call;..\..\..\..\components\drivers\include;..\..\..\..\components\drivers\phy;applications;Libraries\common\board;Libraries\peri_driver;..\..\..\..\include;..\..\..\..\libcpu\arm\common;Libraries\common\chip;.;..\..\..\..\libcpu\arm\cortex-m0;drivers
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  scatter file: .\lpc824_rom.sct
  group Applications
    applications/: application.c
  group Drivers
    drivers/: board.c
  group Kernel
    ../../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    ../../../../src/klibc/: kerrno.c kstdio.c rt_vsnprintf_tiny.c rt_vsscanf.c kstring.c
  group libcpu
    ../../../../libcpu/arm/common/: div0.c showmem.c
    ../../../../libcpu/arm/cortex-m0/: context_rvds.S cpuport.c
  group Libraries
    Libraries/peri_driver/pinint/: pinint_8xx.c
    Libraries/peri_driver/wwdt/: wwdt_8xx.c
    Libraries/peri_driver/acmp/: acmp_8xx.c
    Libraries/peri_driver/iap/: iap.c
    Libraries/peri_driver/spi/: spi_8xx.c
    Libraries/common/board/: board_lpc.c
    Libraries/common/chip/: ioswm_8xx.c syscon_8xx.c sysinit_8xx.c clock_8xx.c
    Libraries/peri_driver/uart/: uart_8xx.c ring_buffer.c
    Libraries/peri_driver/adc/: adc_8xx.c
    Libraries/peri_driver/i2c/: i2c_8xx.c
    Libraries/peri_driver/mrt/: stopwatch.c
    Libraries/peri_driver/dma/: dma_8xx.c
    Libraries/peri_driver/sctimer/: sct_pwm_8xx.c sct_8xx.c
    Libraries/peri_driver/crc/: crc_8xx.c
    Libraries/common/startup/: keil_startup_lpc82x.s
    Libraries/peri_driver/pmu/: pmu_8xx.c
    Libraries/peri_driver/wkt/: wkt_8xx.c
    Libraries/peri_driver/gpio/: gpio_8xx.c
software components: CMSIS:CORE 5.0.1
