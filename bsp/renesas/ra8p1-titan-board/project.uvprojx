# Keil uVision project project.uvprojx, settings and files
target Target_1 (6190000::V6.19::ARMCLANG)
  device: R7KA8P1KF:CPU0 Renesas
  pack: Renesas.RA8x2_DFP.0.0.0
  cpu: CPUTYPE("Cortex-M85") DSP TZ MVE(FP) FPU3(DFPU) PACBTI CLOCK(12000000) ELITTLE
  output: template +hex
  BeforeMake: cmd /c ""$Prasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --generate --compiler ARMv6 --devicefamily ra "$Pconfiguration.xml" 2> "%%TEMP%%\rasc_stderr.out" && echo. > "$Poutput.rasc""
  AfterMake: cmd /c ""$Prasc_launcher.bat" "$Prasc_version.txt" -nosplash --launcher.suppressErrors --gensmartbundle --compiler ARMv6 --devicefamily ra "$Pconfiguration.xml" "$L%L" 2> "%%TEMP%%\rasc_stderr.out""
  c flags: v6Lang=3 v6LangP=6
  c define: __CLK_TCK=RT_TICK_PER_SECOND, __STDC_LIMIT_MACROS, __RTTHREAD__, RT_USING_LIBC, _RA_CORE=0, RT_USING_ARMLIBC
  c include: rt-thread\include;rt-thread\components\libc\compilers\common\extension\fcntl\octal;rt-thread\components\libc\compilers\common\extension;.;libraries\HAL_Drivers\config;rt-thread\components\libc\posix\io\epoll;rt-thread\components\libc\posix\ipc;rt-thread\components\libc\compilers\common\include;rt-thread\components\drivers\phy;rt-thread\components\drivers\include;libraries\HAL_Drivers;board\ports;board;rt-thread\components\libc\posix\io\eventfd;rt-thread\components\libc\posix\io\poll;rt-thread\libcpu\arm\common;rt-thread\components\drivers\include;rt-thread\libcpu\arm\cortex-m85;rt-thread\components\drivers\smp_call;board\ports\wifi;rt-thread\components\drivers\include;rt-thread\components\finsh;rt-thread\components\drivers\include;rt-thread\components\drivers\include
  asm misc: --via=via/rasc_armasm.via
  scatter file: .\script\fsp.scat
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    rt-thread/components/drivers/core/: device.c
    rt-thread/components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/pin/: dev_pin.c
    rt-thread/components/drivers/serial/: dev_serial_v2.c
  group Drivers
    board/: ra8_it.c
    libraries/HAL_Drivers/: drv_common.c drv_gpio.c drv_usart_v2.c
  group Finsh
    rt-thread/components/finsh/: cmd.c msh_parse.c shell.c msh.c
  group Kernel
    rt-thread/src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    rt-thread/src/klibc/: rt_vsnprintf_tiny.c kstdio.c rt_vsscanf.c kstring.c kerrno.c
  group libcpu
    rt-thread/libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m85/: context_gcc.S cpuport.c
software components: Flex Software:RA Configuration 1.0.0
