# Keil uVision project project.uvprojx, settings and files
target RT-Thread IMXRT1052 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: MIMXRT1052:M7 NXP
  pack: NXP.iMXRT_DFP.1.0.2
  cpu: IRAM(0x20000000,0x00060000) IRAM2(0x00000000,0x00020000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: rtthread-imxrt
  AfterMake: fromelf --bin !L --output rtthread-mdk.bin
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: SKIP_SYSCLK_INIT, EVK_MCIMXRM, CPU_MIMXRT1052DVL6B, RT_USING_ARM_LIBC, FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1
  c misc: --library_interface=armcc --library_type=standardlib --diag_suppress=66,1296,186
  c include: applications;.;drivers;drivers\ports;..\Libraries\imxrt1050\drivers;..\..\..\include;..\..\..\libcpu\arm\cortex-m7;..\..\..\libcpu\arm\common;..\..\..\components\dfs\include;..\..\..\components\dfs\filesystems\devfs;..\..\..\components\dfs\filesystems\elmfat;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\spi;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\finsh;..\..\..\components\libc\compilers\armlibc;..\..\..\components\libc\compilers\common;..\Libraries\imxrt1050\CMSIS\Include;..\Libraries\imxrt1050\devices\MIMXRT1052;..\Libraries\imxrt1050\devices\MIMXRT1052\drivers;..\Libraries\imxrt1050\devices\MIMXRT1052\utilities
  memory RVCT9: RAM 0x20000000 size 0x60000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\flexspi_nor.scf
  link misc: --keep *.o(.rti_fn.*)   --keep *.o(FSymTab)
  group Applications
    applications/: lcd_init.c main.c
  group Drivers
    drivers/: board.c drv_flexspi.c
    ../Libraries/imxrt1050/drivers/: drv_uart.c drv_cache.c drv_flexspi_nor.c drv_sdram.c drv_pin.c drv_rtc.c drv_spi_bus.c drv_i2c.c drv_lcd.c drv_sdio.c
  group Kernel
    ../../../src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group CORTEX-M7
    ../../../libcpu/arm/cortex-m7/: cpuport.c context_rvds.S
    ../../../libcpu/arm/common/: backtrace.c div0.c showmem.c
  group Filesystem
    ../../../components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
    ../../../components/dfs/filesystems/devfs/: devfs.c
    ../../../components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
    ../../../components/dfs/filesystems/elmfat/option/: ccsbcs.c
  group DeviceDrivers
    ../../../components/drivers/cputime/: cputime.c cputime_cortexm.c
    ../../../components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/rtc/: rtc.c
    ../../../components/drivers/sdio/: block_dev.c mmcsd_core.c sd.c sdio.c mmc.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/spi/: spi_core.c spi_dev.c
    ../../../components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
  group finsh
    ../../../components/finsh/: shell.c symbol.c cmd.c msh.c msh_cmd.c msh_file.c
  group libc
    ../../../components/libc/compilers/armlibc/: libc.c mem_std.c stdio.c stubs.c time.c
    ../../../components/libc/compilers/common/: gmtime_r.c
  group Libraries
    ../Libraries/imxrt1050/devices/MIMXRT1052/drivers/: fsl_adc.c fsl_adc_etc.c fsl_aipstz.c fsl_aoi.c fsl_bee.c fsl_cache.c fsl_clock.c fsl_cmp.c fsl_common.c fsl_csi.c fsl_dcdc.c fsl_dcp.c fsl_dmamux.c fsl_edma.c fsl_elcdif.c fsl_enc.c fsl_enet.c fsl_ewm.c fsl_flexcan.c fsl_flexio.c fsl_flexio_i2c_master.c fsl_flexio_i2s.c fsl_flexio_i2s_edma.c fsl_flexio_spi.c fsl_flexio_spi_edma.c fsl_flexio_uart.c fsl_flexio_uart_edma.c fsl_flexram.c fsl_flexspi.c fsl_gpc.c fsl_gpio.c fsl_gpt.c fsl_kpp.c fsl_lpi2c.c fsl_lpi2c_edma.c fsl_lpspi.c fsl_lpspi_edma.c fsl_lpuart.c fsl_lpuart_edma.c fsl_pit.c fsl_pmu.c fsl_pwm.c fsl_pxp.c fsl_qtmr.c fsl_rtwdog.c fsl_sai.c fsl_sai_edma.c fsl_semc.c fsl_snvs_hp.c fsl_snvs_lp.c fsl_spdif.c fsl_spdif_edma.c fsl_src.c fsl_trng.c fsl_tsc.c fsl_usdhc.c fsl_wdog.c fsl_xbara.c fsl_xbarb.c
    ../Libraries/imxrt1050/devices/MIMXRT1052/: system_MIMXRT1052.c
    ../Libraries/imxrt1050/devices/MIMXRT1052/arm/: startup_MIMXRT1052.s
software components: CMSIS:CORE 5.0.2
