# Keil uVision project project.uvprojx, settings and files
target rtthread (6140000::V6.14::ARMCLANG)
  device: STM32H563ZITx STMicroelectronics
  pack: Keil.STM32H5xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00050000) IRAM2(0x20050000,0x00050000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: __STDC_LIMIT_MACROS, RT_USING_LIBC, STM32H503xx, RT_USING_ARMLIBC, __CLK_TCK=RT_TICK_PER_SECOND, USE_HAL_DRIVER, __RTTHREAD__
  c include: ..\..\..\components\drivers\include;..\libraries\HAL_Drivers\CMSIS\Include;..\..\..\include;..\..\..\libcpu\arm\cortex-m33;..\libraries\STM32H5xx_HAL\STM32H5xx_HAL_Driver\Inc;..\..\..\components\drivers\phy;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\libraries\STM32H5xx_HAL\CMSIS\Device\ST\STM32H5xx\Include;..\..\..\components\drivers\include;..\..\..\components\libc\posix\io\eventfd;..\..\..\components\drivers\spi;board;..\..\..\libcpu\arm\common;..\..\..\components\libc\posix\io\poll;.;..\..\..\components\finsh;..\..\..\components\libc\compilers\common\include;..\..\..\components\drivers\include;..\..\..\components\libc\compilers\common\extension;..\..\..\components\drivers\include;..\libraries\HAL_Drivers\drivers\config;..\..\..\components\libc\posix\ipc;board\CubeMX_Config\Inc;..\..\..\components\libc\posix\io\epoll;..\..\..\components\drivers\include;..\..\..\components\drivers\smp_call;..\libraries\HAL_Drivers;..\libraries\HAL_Drivers\drivers;applications;..\..\..\components\libc\compilers\common\extension\fcntl\octal
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x50000
  memory RVCT10: RAM 0x20050000 size 0x50000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/i2c/: dev_i2c_bit_ops.c dev_i2c_core.c dev_i2c_dev.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/misc/: adc.c rt_drv_pwm.c
    ../../../components/drivers/pin/: dev_pin.c
    ../../../components/drivers/serial/: dev_serial.c
    ../../../components/drivers/spi/: dev_spi.c dev_spi_core.c
  group Drivers
    ../libraries/HAL_Drivers/drivers/: drv_adc.c drv_gpio.c drv_spi.c drv_usart.c
    ../libraries/HAL_Drivers/: drv_common.c
    ../libraries/STM32H5xx_HAL/CMSIS/Device/ST/STM32H5xx/Source/Templates/arm/: startup_stm32h503xx.s
    board/CubeMX_Config/Src/: stm32h5xx_hal_msp.c
    board/: board.c
  group Finsh
    ../../../components/finsh/: msh_parse.c shell.c msh.c cmd.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    ../../../src/klibc/: rt_vsnprintf_tiny.c kstdio.c kerrno.c kstring.c rt_vsscanf.c
  group libcpu
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m33/: context_rvds.S cpuport.c syscall_rvds.S trustzone.c
  group Libraries
    ../libraries/STM32H5xx_HAL/STM32H5xx_HAL_Driver/Src/: stm32h5xx_hal_lptim.c stm32h5xx_hal_icache.c stm32h5xx_hal_gpio.c stm32h5xx_hal_usart_ex.c stm32h5xx_hal_exti.c stm32h5xx_hal_spi_ex.c stm32h5xx_hal_crc_ex.c stm32h5xx_hal_i2c_ex.c stm32h5xx_hal_i2c.c stm32h5xx_hal_adc_ex.c stm32h5xx_hal_tim.c stm32h5xx_hal_uart_ex.c stm32h5xx_hal_spi.c stm32h5xx_hal.c stm32h5xx_hal_cryp_ex.c stm32h5xx_hal_crc.c stm32h5xx_hal_cortex.c stm32h5xx_hal_rng.c stm32h5xx_hal_uart.c stm32h5xx_hal_dma_ex.c stm32h5xx_hal_rcc.c stm32h5xx_hal_pwr.c stm32h5xx_hal_tim_ex.c stm32h5xx_hal_cryp.c stm32h5xx_hal_comp.c stm32h5xx_hal_dma.c stm32h5xx_hal_usart.c stm32h5xx_hal_rcc_ex.c stm32h5xx_hal_pwr_ex.c stm32h5xx_hal_adc.c
    ../libraries/STM32H5xx_HAL/CMSIS/Device/ST/STM32H5xx/Source/Templates/: system_stm32h5xx.c
