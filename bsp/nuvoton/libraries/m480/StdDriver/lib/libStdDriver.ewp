# IAR project libStdDriver.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: M481AE series Nuvoton M480AE series (M481AE,M482AE,M483AE,M484AE,M485AE,M487AE)
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\Device\Nuvoton\M480\Include; ..\..\CMSIS\Include; ..\inc; $PROJ_DIR$
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: rtthread.bin
  ILINK.IlinkOutputFile: Template.out
  ILINK.IlinkIcfFile: linking_scripts\m2354_flash.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: Template.srec
  group src
    ../src/: nu_acmp.c nu_bpwm.c nu_can.c nu_ccap.c nu_clk.c nu_crc.c nu_crypto.c nu_dac.c nu_eadc.c nu_ebi.c nu_ecap.c nu_emac.c nu_epwm.c nu_fmc.c nu_gpio.c nu_hsusbd.c nu_i2c.c nu_i2s.c nu_pdma.c nu_qei.c nu_qspi.c nu_rtc.c nu_sc.c nu_scuart.c nu_sdh.c nu_spi.c nu_spim.c nu_sys.c nu_timer.c nu_timer_pwm.c nu_trng.c nu_uart.c nu_usbd.c nu_usci_i2c.c nu_usci_spi.c nu_usci_uart.c nu_wdt.c nu_wwdt.c
