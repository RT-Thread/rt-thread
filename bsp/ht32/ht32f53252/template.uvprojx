# Keil uVision project template.uvprojx, settings and files
target rt-thread (ARM-ADS)
  device: HT32F53252 Holtek
  pack: Holtek.HT32_DFP.1.0.55
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x00000000-0x0001FBFF) CLOCK(8000000) CPUTYPE("Cortex-M0+")
  output: rt-thread
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --gnu
  asm define: USE_HT32_CHIP=28
  memory RVCT4: ROM 0x0 size 0x1fc00
  memory RVCT9: RAM 0x20000000 size 0x4000
