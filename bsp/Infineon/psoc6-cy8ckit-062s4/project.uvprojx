# Keil uVision project project.uvprojx, settings and files
target rtthread (ARM-ADS)
  device: CY8C6244LQI-S4D92:Cortex-M4 Cypress
  pack: Cypress.PSoC6_DFP.1.2.0
  cpu: IRAM(0x08000000,0x20000) IROM(0x10000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: CY_USING_HAL, __STDC_LIMIT_MACROS, RT_USING_ARMLIBC, CORE_NAME_CM0P_0, COMPONENT_CAT1A, RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND, COMPONENT_BSP_DESIGN_MODUS, CY_USING_PREBUILT_CM0P_IMAGE, __RTTHREAD__, COMPONENT_CAT1, CY8C6244LQI_S4D92, CORE_NAME_CM4_0
  c include: ..\libraries\IFX_PSOC6_HAL\mtb-hal-cat1\include;board;..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\libcpu\arm\cortex-m4;..\libraries\HAL_Drivers\config;..\libraries\IFX_PSOC6_HAL\mtb-pdl-cat1\drivers\include;..\libraries\IFX_PSOC6_HAL\mtb-pdl-cat1\devices\COMPONENT_CAT1A\include;..\libraries\IFX_PSOC6_HAL\mtb_shared\usbdev;..\libraries\IFX_PSOC6_HAL\mtb_shared\csdidac;..\libraries\IFX_PSOC6_HAL\mtb-hal-cat1\include_pvt;..\libraries\IFX_PSOC6_HAL\mtb_shared\serial-flash;..\..\..\components\libc\compilers\common\include;..\libraries\IFX_PSOC6_HAL\psoc6cm0p;libs\TARGET_CY8CKIT-062S4;libs\TARGET_CY8CKIT-062S4\config\GeneratedSource;..\libraries\IFX_PSOC6_HAL\retarget-io;..\..\..\components\finsh;..\..\..\components\libc\posix\io\epoll;..\..\..\libcpu\arm\common;..\..\..\components\drivers\include;..\..\..\include;applications;..\..\..\components\libc\posix\io\eventfd;..\libraries\IFX_PSOC6_HAL\capsense;..\..\..\components\libc\posix\io\poll;.;..\..\..\components\drivers\include;board\ports;..\libraries\IFX_PSOC6_HAL\mtb-hal-cat1\COMPONENT_CAT1A\include;..\..\..\components\libc\compilers\common\extension;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\libraries\IFX_PSOC6_HAL\mtb-pdl-cat1\cmsis\include;..\..\..\components\libc\posix\ipc;..\libraries\IFX_PSOC6_HAL\core-lib\include;..\libraries\HAL_Drivers
  memory RVCT4: ROM 0x10000000 size 0x40000
  memory RVCT9: RAM 0x8000000 size 0x20000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/ipc/: completion.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/pin/: pin.c
    ../../../components/drivers/serial/: serial.c
  group Drivers
    ../libraries/IFX_PSOC6_HAL/mtb-pdl-cat1/drivers/source/TOOLCHAIN_ARM/: cy_syslib_ext.S
    board/: board.c
    ../libraries/HAL_Drivers/: drv_common.c drv_gpio.c drv_uart.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../../src/: clock.c components.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
    ../../../src/klibc/: kstdio.c kstring.c
  group libcpu
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group Libraries
    ../libraries/IFX_PSOC6_HAL/retarget-io/: cy_retarget_io.c
    ../libraries/IFX_PSOC6_HAL/psoc6cm0p/COMPONENT_CM0P_SLEEP/: psoc6_04_cm0p_sleep.c psoc6_01_cm0p_sleep.c psoc6_03_cm0p_sleep.c psoc6_02_cm0p_sleep.c
    ../libraries/IFX_PSOC6_HAL/mtb-pdl-cat1/drivers/source/: cy_scb_i2c.c cy_gpio.c cy_scb_uart.c cy_scb_common.c cy_ipc_sema.c cy_ipc_drv.c cy_syslib.c cy_ipc_pipe.c cy_prot.c cy_mcwdt.c cy_sysclk.c cy_sysint.c cy_systick.c cy_trigmux.c cy_flash.c cy_ble_clk.c cy_syspm.c
    ../libraries/IFX_PSOC6_HAL/mtb-hal-cat1/source/: cyhal_irq_impl.c cyhal_scb_common.c cyhal_clock.c cyhal_utils_impl.c cyhal_gpio.c cyhal_system.c cyhal_utils.c cyhal_hwmgr.c cyhal_lptimer.c cyhal_syspm.c cyhal_interconnect.c cyhal_uart.c
    ../libraries/IFX_PSOC6_HAL/mtb-hal-cat1/COMPONENT_CAT1A/source/triggers/: cyhal_triggers_psoc6_04.c
    ../libraries/IFX_PSOC6_HAL/mtb-hal-cat1/COMPONENT_CAT1A/source/pin_packages/: cyhal_psoc6_04_68_qfn.c
    ../libraries/IFX_PSOC6_HAL/mtb-pdl-cat1/devices/COMPONENT_CAT1A/source/: cy_device.c
  group libs
    libs/TARGET_CY8CKIT-062S4/config/GeneratedSource/: cycfg_routing.c cycfg_capsense.c cycfg.c cycfg_clocks.c cycfg_pins.c cycfg_peripherals.c cycfg_qspi_memslot.c cycfg_system.c
    libs/TARGET_CY8CKIT-062S4/COMPONENT_CM4/TOOLCHAIN_ARM/: startup_psoc6_04_cm4.S
    libs/TARGET_CY8CKIT-062S4/: cybsp.c
    libs/TARGET_CY8CKIT-062S4/COMPONENT_CM4/: system_psoc6_cm4.c
