# Keil uVision project motor_demo_twrk64f120m.uvprojx, settings and files
target motor_demo_twrk64f120m Debug (ARM-ADS)
  device: MK64FN1M0xxx12 Freescale
  cpu: CPUTYPE("Cortex-M4.fp")
  output: motor_demo.out
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: DEBUG, CPU_MK64FN1M0VMD12, TWR_K64F120M, EMPL_TARGET_KINETIS, MPU6050, EMPL, USE_DMP
  c misc: --library_interface=armcc 
--library_type=standardlib 
--c99 
--diag_suppress=1296,186 
--diag_suppress=66
  c include: ../../../../bsp/freescale/platform/devices;../../../../bsp/freescale/platform/devices/MK64F12/include;../../../../bsp/freescale/platform/devices/MK64F12/startup;../../../../bsp/freescale/boards/twrk64f120m;../../../../bsp/freescale/common/sgtl5000;../../../../bsp/freescale/common/phyksz8041;../../../../bsp/freescale/platform/system/src/clock/MK64F12;../../../../utils/mdp/core/driver/eMPL;../../../../utils/mdp/core/driver/include;../../../../utils/mdp/core/mllite;../../../../utils/mdp/core/mpl;../../../../utils/mdp/core/eMPL-hal;../../../../bsp/freescale/motor_app;../../../../bsp/freescale/platform/drivers/inc;../../../../bsp/freescale/platform/hal/inc;../../../../bsp/freescale/rtos;../../../../bsp/freescale/platform/osa/inc;../../../../bsp/freescale/platform/CMSIS/Include;../../../../bsp/freescale/platform/system/inc;../../../../bsp/freescale/platform/utilities/inc;../../../../bsp/freescale/platform/utilities/src;../../../../components/drivers/include/drivers;../../../../components/drivers/include;../../../../bsp/freescale/driver_wrapper/inc;../../../../components/finsh;../../../../include
  asm define: CPU_MK64FN1M0VMD12, DEBUG,__CC_ARM,KEIL,TWR_K64F120M, TOWER
  asm misc: --cpreproc_opts '-DDEBUG'
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: ../../../../bsp/freescale/platform/devices/MK64F12/linker/arm/MK64FN1M0xxx12_flash.scf
  link misc: ../../../../utils/mdp/core/mpl/arm/Keil/libmpllib_Keil_M4FP/libmpllib.lib 
../../../../lib/ksdk_platform_lib/KsdkPlatformLib/mdk/debug/libksdk_platform.lib 
--remove 
--predefine="-D__ram_vector_table__=1"
  group startup
    ../../../../bsp/freescale/platform/devices/MK64F12/startup/arm/: startup_MK64F12.s
    ../../../../bsp/freescale/platform/devices/MK64F12/startup/: system_MK64F12.c system_MK64F12.c system_MK64F12.c system_MK64F12.c system_MK64F12.c system_MK64F12.c system_MK64F12.c system_MK64F12.c system_MK64F12.c system_MK64F12.c system_MK64F12.c system_MK64F12.c system_MK64F12.c
    ../../../../bsp/freescale/platform/devices/: startup.c startup.h startup.c startup.h startup.c startup.h startup.c startup.h startup.c startup.h startup.c startup.h startup.c startup.h startup.c startup.h startup.c startup.h startup.c startup.h startup.c startup.h startup.c startup.h startup.c startup.h
  group context
    ../../../../libcpu/arm/cortex-m4/: context_rvds.S
  group uart_wrapper
    ../../../../bsp/freescale/driver_wrapper/uart/: drv_uart.c fsl_uart_irq_rt.c
    ../../../../bsp/freescale/driver_wrapper/inc/: drv_uart.h
  group board
    ../../../../bsp/freescale/boards/twrk64f120m/: gpio_pins.c gpio_pins.h board.c board.h pin_mux.c pin_mux.h gpio_pins.c gpio_pins.h board.c board.h pin_mux.c pin_mux.h gpio_pins.c gpio_pins.h board.c board.h pin_mux.c pin_mux.h gpio_pins.c gpio_pins.h board.c board.h pin_mux.c pin_mux.h gpio_pins.c gpio_pins.h board.c board.h pin_mux.c pin_mux.h gpio_pins.c gpio_pins.h board.c board.h pin_mux.c pin_mux.h gpio_pins.c gpio_pins.h board.c board.h pin_mux.c pin_mux.h gpio_pins.c gpio_pins.h board.c board.h pin_mux.c pin_mux.h gpio_pins.c gpio_pins.h board.c board.h pin_mux.c pin_mux.h gpio_pins.c gpio_pins.h board.c board.h pin_mux.c pin_mux.h gpio_pins.c gpio_pins.h board.c board.h pin_mux.c pin_mux.h gpio_pins.c gpio_pins.h board.c board.h pin_mux.c pin_mux.h gpio_pins.c gpio_pins.h board.c board.h pin_mux.c pin_mux.h
  group utils
    ../../../../bsp/freescale/boards/twrk64f120m/: rtconfig.h
    ../../../../bsp/freescale/platform/utilities/src/: fsl_debug_console.c print_scan.c print_scan.h fsl_misc_utilities.c
    ../../../../bsp/freescale/platform/utilities/inc/: fsl_debug_console.h
  group app_src
    ../../../../bsp/freescale/motor_app/: fsl_gpio_irq.c application.c mpu6050_function.c mpu6050.c mpu6050.h packet.h log_kinetis.c startup_app.c board_app.c board_app.h app_config.h app_config.c
  group mdp:core:driver:eMPL
    ../../../../utils/mdp/core/driver/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c inv_mpu.h inv_mpu_dmp_motion_driver.h dmpKey.h dmpmap.h
  group mdp:core:driver:include
    ../../../../utils/mdp/core/driver/include/: mltypes.h log.h mlinclude.h mlmath.h mlos.h mpu.h stdint_invensense.h
  group mdp:core:eMPL-hal
    ../../../../utils/mdp/core/eMPL-hal/: eMPL_outputs.c eMPL_outputs.h
  group mdp:core:mllite
    ../../../../utils/mdp/core/mllite/: hal_outputs.c data_builder.c data_builder.h hal_outputs.h invensense.h message_layer.c message_layer.h ml_math_func.c ml_math_func.h mlmath.c mpl.c mpl.h results_holder.c results_holder.h start_manager.c start_manager.h storage_manager.c storage_manager.h
  group mdp:core:mpl
    ../../../../utils/mdp/core/mpl/: gyro_tc.h fast_no_motion.h compass_vec_cal.h mag_disturb.h motion_no_motion.h no_gyro_fusion.h quaternion_supervisor.h accel_auto_cal.h fusion_9axis.h heading_from_gyro.h inv_math.h invensense_adv.h
  group mdp:core:hal
    ../../../../utils/mdp/core/eMPL-hal/: eMPL_outputs.c eMPL_outputs.h
  group general
    ../../../../components/drivers/src/: completion.c pipe.c portal.c ringbuffer.c workqueue.c dataqueue.c
  group finsh
    ../../../../components/finsh/: cmd.c finsh.h finsh_compiler.c finsh_error.c finsh_error.h finsh_heap.c finsh_heap.h finsh_init.c finsh_node.c finsh_node.h finsh_ops.c finsh_ops.h finsh_parser.c finsh_parser.h finsh_token.c finsh_token.h finsh_var.c finsh_var.h finsh_vm.c finsh_vm.h msh.c msh.h msh_cmd.c shell.c shell.h symbol.c
  group serial
    ../../../../components/drivers/serial/: serial.c
    ../../../../components/drivers/include/drivers/: serial.h
  group rt_core
    ../../../../src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c module.c object.c scheduler.c slab.c thread.c timer.c
  group cortex_m4
    ../../../../libcpu/arm/cortex-m4/: cpuport.c
  group arm
    ../../../../libcpu/arm/common/: backtrace.c div0.c showmem.c
target motor_demo_twrk64f120m Release (ARM-ADS)
  device: MK64FN1M0xxx12 Freescale
  cpu: CPUTYPE("Cortex-M4.fp")
  output: motor_demo.out
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: NDEBUG, CPU_MK64FN1M0VMD12, TWR_K64F120M, EMPL_TARGET_KINETIS, MPU6050, EMPL, USE_DMP
  c misc: as above
  c include: as above
  asm define: CPU_MK64FN1M0VMD12, NDEBUG,__CC_ARM,KEIL,TWR_K64F120M, TOWER
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  scatter file: as above
  link misc: ../../../../utils/mdp/core/mpl/arm/Keil/libmpllib_Keil_M4FP/libmpllib.lib 
../../../../lib/ksdk_platform_lib/KsdkPlatformLib/mdk/release/libksdk_platform.lib 
--remove 
--predefine="-D__ram_vector_table__=1"
