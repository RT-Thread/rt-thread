# Keil uVision project template.uvprojx, settings and files
target rtthread (ARM-ADS)
  device: Nuvoton_ARM9_Series Nuvoton
  output: rtthread +hex
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --c99
  memory RVCT1: ROM 0x20000000 size 0x800000
  memory RVCT4: ROM 0x100000 size 0x8000
  memory RVCT6: RAM 0x20800000 size 0x1800000
  memory RVCT9: RAM 0x200000 size 0x1000
  memory RVCT10: RAM 0x300000 size 0x1000
  scatter file: .\linking_scripts\nuc980.sct
