# IAR project project.ewp, settings and files
configuration rtthread (ARM, debug)
  General.OGChipSelectEditMenu: STM32H750VB ST STM32H750VB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; _DLIB_FILE_DESCRIPTOR; STM32H750xx; __RTTHREAD__; USE_HAL_DRIVER; __RT_IPC_SOURCE__; __RT_KERNEL_SOURCE__
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\components\drivers\spi; board\port\lcd; applications; ..\..\..\components\libc\posix\ipc; ..\..\..\components\libc\posix\io\eventfd; ..\libraries\STM32H7xx_HAL\STM32H7xx_HAL_Driver\Inc\Legacy; ..\libraries\STM32H7xx_HAL\STM32H7xx_HAL_Driver\Inc; ..\..\..\components\libc\compilers\common\include; board; ..\..\..\components\drivers\include; ..\..\..\components\libc\compilers\common\extension\fcntl\octal; ..\..\..\components\finsh; ..\libraries\HAL_Drivers\drivers\config; ..\..\..\libcpu\arm\cortex-m7; ..\..\..\libcpu\arm\common; ..\..\..\components\drivers\phy; ..\..\..\components\dfs\dfs_v1\filesystems\devfs; ..\..\..\include; ..\libraries\HAL_Drivers; board\CubeMX_Config\Inc; ..\libraries\HAL_Drivers\CMSIS\Include; ..\..\..\components\libc\posix\io\epoll; board\port; ..\..\..\components\libc\compilers\common\extension; ..\libraries\STM32H7xx_HAL\CMSIS\Device\ST\STM32H7xx\Include; ..\..\..\components\libc\posix\io\poll; ..\..\..\components\dfs\dfs_v1\include; ..\..\..\components\drivers\smp_call; ..\libraries\HAL_Drivers\drivers; ..\..\..\components\drivers\spi\sfud\inc; .
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../../rtthread.bin
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: main.c
  group Compiler
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/i2c/: dev_i2c_bit_ops.c dev_i2c_core.c dev_i2c_dev.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/pin/: dev_pin.c
    ../../../components/drivers/rtc/: dev_rtc.c
    ../../../components/drivers/serial/: dev_serial_v2.c
    ../../../components/drivers/spi/: dev_qspi_core.c dev_spi.c dev_spi_core.c dev_spi_flash_sfud.c
    ../../../components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
  group Drivers
    ../libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32H7xx/Source/Templates/iar/: startup_stm32h750xx.s
    board/CubeMX_Config/Src/: stm32h7xx_hal_msp.c
    board/: board.c
    board/port/lcd/: drv_lcd_spi.c drv_lcd_spi_ext.c
    ../libraries/HAL_Drivers/drivers/: drv_gpio.c drv_qspi.c drv_spi.c drv_usart_v2.c
    ../libraries/HAL_Drivers/: drv_common.c
  group Filesystem
    ../../../components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    ../../../components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    ../../../components/finsh/: cmd.c msh_file.c msh.c shell.c msh_parse.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    ../../../src/klibc/: kerrno.c kstdio.c rt_vsscanf.c kstring.c rt_vsnprintf_tiny.c
  group libcpu
    ../../../libcpu/arm/common/: div0.c showmem.c
    ../../../libcpu/arm/cortex-m7/: context_iar.S cpu_cache.c cpuport.c
  group Libraries
    ../libraries/STM32H7xx_HAL/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_uart.c stm32h7xx_hal_cryp.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal.c stm32h7xx_hal_rtc.c stm32h7xx_hal_pwr.c stm32h7xx_hal_cortex.c stm32h7xx_hal_i2c.c stm32h7xx_hal_dma.c stm32h7xx_hal_qspi.c stm32h7xx_hal_mdma.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rng.c stm32h7xx_hal_sram.c stm32h7xx_hal_usart.c stm32h7xx_hal_gpio.c stm32h7xx_hal_cryp_ex.c stm32h7xx_hal_cec.c stm32h7xx_hal_rcc.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_comp.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_crc.c
    ../libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
