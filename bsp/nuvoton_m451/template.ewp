# IAR project template.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M451AE series Nuvoton M451AE series (M451AE,M452AE,M453AE,M451MAE)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Template.bin
  ILINK.IlinkOutputFile: Template.out
  ILINK.IlinkProgramEntryLabel: Reset_Handler
