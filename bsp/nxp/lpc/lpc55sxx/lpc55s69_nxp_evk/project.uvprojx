# Keil uVision project project.uvprojx, settings and files
target rtthread-lpc55s6x (6160000::V6.16::ARMCLANG)
  device: LPC55S69JBD100:cm33_core0 NXP
  pack: NXP.LPC55S69_DFP.14.0.0
  cpu: IRAM(0x20000000,0x044000) IRAM2(0x04000000,0x8000) IROM(0x00000000,0x098000) XRAM(0x40100000,0x4000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: rtthread
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=3
  c define: __STDC_LIMIT_MACROS, RT_USING_ARMLIBC, RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND, __RTTHREAD__, CPU_LPC55S69JBD100_cm33_core0, DEBUG
  c misc: --target=arm-arm-none-eabi
  c include: ..\Libraries\LPC55S6X\components\codec;..\..\..\..\..\components\libc\compilers\common\extension\fcntl\octal;board;..\Libraries\drivers;.;..\Libraries\LPC55S6X\LPC55S6X;..\..\..\..\..\components\libc\compilers\common\include;..\Libraries\LPC55S6X\middleware\sdmmc\inc;..\..\..\..\..\components\finsh;..\..\..\..\..\components\libc\posix\io\epoll;..\..\..\..\..\libcpu\arm\common;..\..\..\..\..\components\drivers\include;..\..\..\..\..\include;..\Libraries\LPC55S6X\middleware\sdmmc\port;..\..\..\..\..\components\libc\posix\io\eventfd;..\..\..\..\..\components\libc\posix\ipc;..\..\..\..\..\components\libc\posix\io\poll;applications;..\..\..\..\..\libcpu\arm\cortex-m33;..\..\..\..\..\components\drivers\include;board\MCUX_Config\board;..\..\..\..\..\components\libc\compilers\common\extension;..\..\..\..\..\components\drivers\include;..\Libraries\LPC55S6X\LPC55S6X\drivers;..\..\..\..\..\components\drivers\include;..\Libraries\CMSIS\Core\Include
  asm misc: -x assembler-with-cpp
  memory RVCT4: ROM 0x0 size 0x98000
  memory RVCT6: RAM 0x40100000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x44000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: .\board\linker_scripts\LPC55S69_cm33_core0_flash.scf
  group Applications
    applications/: main.c
  group Compiler
    ../../../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../../../components/drivers/core/: device.c
    ../../../../../components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../../components/drivers/pin/: pin.c
    ../../../../../components/drivers/serial/: serial.c
  group Drivers
    board/MCUX_Config/board/: clock_config.c pin_mux.c
    board/: board.c
    ../Libraries/drivers/: drv_pin.c drv_uart.c
  group Finsh
    ../../../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../../../../src/: clock.c components.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
    ../../../../../src/klibc/: kstdio.c kstring.c
  group libcpu
    ../../../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../../../libcpu/arm/cortex-m33/: context_rvds.S cpuport.c syscall_rvds.S trustzone.c
  group Libraries
    ../Libraries/LPC55S6X/LPC55S6X/drivers/: fsl_hashcrypt.c fsl_usart_dma.c fsl_spi_dma.c fsl_cmp.c fsl_utick.c fsl_common_arm.c fsl_power.c fsl_i2s_dma.c fsl_gpio.c fsl_casper.c fsl_clock.c fsl_wwdt.c fsl_reset.c fsl_sctimer.c fsl_common.c fsl_rtc.c fsl_crc.c fsl_sdif.c fsl_plu.c fsl_mrt.c fsl_i2s.c fsl_spi.c fsl_ctimer.c fsl_gint.c fsl_dma.c fsl_sysctl.c fsl_flexcomm.c fsl_pint.c fsl_powerquad_basic.c fsl_usart.c fsl_puf.c fsl_rng.c fsl_lpadc.c fsl_inputmux.c fsl_i2c_dma.c fsl_i2c.c fsl_anactrl.c fsl_iap.c fsl_ostimer.c
    ../Libraries/LPC55S6X/LPC55S6X/arm/: startup_LPC55S69_cm33_core0.s
    ../Libraries/LPC55S6X/LPC55S6X/: system_LPC55S69_cm33_core0.c
