# Keil uVision project project.uvprojx, settings and files
target rtthread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MIMXRT1064DVL6A NXP
  pack: NXP.MIMXRT1064_DFP.10.0.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x00000000,0x020000) IROM(0x70000000,0x400000) XRAM(0x20200000,0x0c0000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rtthread
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: XIP_BOOT_HEADER_DCD_ENABLE=1, SKIP_SYSCLK_INIT, __FPU_PRESENT=1, CPU_MIMXRT1064DVL6A, __RTTHREAD__, XIP_BOOT_HEADER_ENABLE=1, FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1, __CLK_TCK=RT_TICK_PER_SECOND, XIP_EXTERNAL_FLASH=1, EVK_MCIMXRM, RT_USING_ARM_LIBC
  c misc: --library_interface=armcc --library_type=standardlib --diag_suppress=66,1296,186
  c include: applications;..\..\..\libcpu\arm\common;..\..\..\libcpu\arm\cortex-m7;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;board;board\MCUX_Config;board\ports;..\libraries\drivers;..\libraries\drivers\config;..\..\..\components\finsh;.;..\..\..\include;..\..\..\components\libc\compilers\armlibc;..\..\..\components\libc\compilers\common;..\..\..\components\libc\compilers\common\nogcc;..\libraries\MIMXRT1064\CMSIS\Include;..\libraries\MIMXRT1064\MIMXRT1064;..\libraries\MIMXRT1064\MIMXRT1064\drivers;..\libraries\peripherals;..\..\..\examples\utest\testcases\kernel;xip
  memory RVCT4: ROM 0x70000000 size 0x400000
  memory RVCT6: RAM 0x20200000 size 0xc0000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\board\linker_scripts\link.sct
  link misc: --keep=*(.boot_hdr.ivt)--keep=*(.boot_hdr.boot_data)--keep=*(.boot_hdr.dcd_data)--keep=*(.boot_hdr.conf)
  group Applications
    applications/: main.c
  group CPU
    ../../../libcpu/arm/common/: div0.c showmem.c backtrace.c
    ../../../libcpu/arm/cortex-m7/: context_rvds.S cpuport.c cpu_cache.c
  group DeviceDrivers
    ../../../components/drivers/cputime/: cputime.c
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/src/: dataqueue.c ringbuffer.c waitqueue.c completion.c workqueue.c ringblk_buf.c pipe.c
  group Drivers
    board/MCUX_Config/: pin_mux.c clock_config.c
    board/: board.c
    ../libraries/drivers/: drv_gpio.c drv_uart.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c cmd.c
  group Kernel
    ../../../src/: idle.c irq.c memheap.c thread.c device.c kservice.c timer.c scheduler.c clock.c object.c ipc.c mempool.c components.c
  group libc
    ../../../components/libc/compilers/armlibc/: syscalls.c libc.c mem_std.c
    ../../../components/libc/compilers/common/: time.c stdlib.c
  group Libraries
    ../libraries/MIMXRT1064/MIMXRT1064/drivers/: fsl_common.c fsl_clock.c fsl_gpio.c fsl_cache.c fsl_lpuart.c
    ../libraries/MIMXRT1064/MIMXRT1064/arm/: startup_MIMXRT1064.s
    ../libraries/MIMXRT1064/MIMXRT1064/: system_MIMXRT1064.c
  group xip
    xip/: evkmimxrt1064_sdram_ini_dcd.c evkmimxrt1064_flexspi_nor_config.c fsl_flexspi_nor_boot.c
