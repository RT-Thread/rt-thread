# Keil uVision project project.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: R7FA8D1BH Renesas
  pack: Renesas.RA8_DFP.0.0.2
  cpu: IRAM(0x22000000,0xE0000) IRAM2(0x0,0x10000) IROM(0x02000000,0x001F8000) XRAM(0x20000000,0x10000) CPUTYPE("Cortex-M85") FPU3(DFPU) DSP TZ MVE(FP) PACBTI CLOCK(12000000) ELITTLE
  output: rtthread +hex
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3
  c define: __STDC_LIMIT_MACROS, RT_USING_ARMLIBC, __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND, RT_USING_LIBC
  c misc: -Wno-license-management -Wuninitialized -Wall -Wmissing-declarations -Wpointer-arith -Waggregate-return -Wfloat-equal
  c include: board\ports\wifi;..\..\..\components\libc\compilers\common\extension;..\libraries\HAL_Drivers\drivers;..\..\..\components\drivers\include;ra_cfg\fsp_cfg;ra_cfg\fsp_cfg\bsp;..\..\..\components\drivers\include;..\..\..\components\libc\compilers\common\include;..\..\..\libcpu\arm\cortex-m85;..\libraries\HAL_Drivers;..\libraries\HAL_Drivers\drivers\config;..\..\..\components\drivers\include;board\ports;..\..\..\components\libc\posix\io\epoll;..\..\..\components\drivers\include;..\..\..\components\net\utest;..\..\..\components\libc\posix\io\eventfd;..\..\..\components\finsh;board;.;ra\fsp\inc\instances;ra\fsp\inc\api;..\..\..\components\libc\posix\ipc;..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\include;ra\fsp\inc;ra\arm\CMSIS_5\CMSIS\Core\Include;..\..\..\components\drivers\smp_call;..\..\..\libcpu\arm\common;..\..\..\components\drivers\phy;ra_gen;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\libc\posix\io\poll
  memory RVCT4: ROM 0x2000000 size 0x1f8000
  memory RVCT6: RAM 0x20000000 size 0x10000
  memory RVCT9: RAM 0x22000000 size 0xe0000
  memory RVCT10: RAM 0x0 size 0x10000
  scatter file: .\script\fsp.scat
  group Applications
    src/: hal_entry.c
  group CPU
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m85/: context_gcc.S cpuport.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/pin/: dev_pin.c
    ../../../components/drivers/serial/: dev_serial_v2.c
  group Drivers
    board/ports/: drv_sdram.c
    board/: ra8_it.c
    ../libraries/HAL_Drivers/drivers/: drv_gpio.c drv_usart_v2.c
    ../libraries/HAL_Drivers/: drv_common.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group Libc
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
  group ra
    ra/fsp/src/bsp/mcu/all/: bsp_clocks.c bsp_common.c bsp_delay.c bsp_group_irq.c bsp_guard.c bsp_io.c bsp_irq.c bsp_register_protection.c bsp_rom_registers.c bsp_sbrk.c bsp_security.c
    ra/fsp/src/bsp/cmsis/Device/RENESAS/Source/: system.c startup.c
    ra/fsp/src/r_ioport/: r_ioport.c
    ra/fsp/src/r_sci_b_uart/: r_sci_b_uart.c
  group ra_gen
    ra_gen/: common_data.c hal_data.c main.c pin_data.c vector_data.c
software components: Flex Software:RA Configuration 1.0.0
