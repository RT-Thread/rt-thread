# Keil uVision project project.uvprojx, settings and files
target rtthread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MAX32660 Maxim
  pack: Maxim.MAX32660.1.2.0
  cpu: IRAM(0x20000000,0x00018000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: TARGET=32660, TARGET_REV=0x4131, __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND
  c include: applications;.;..\..\..\libcpu\arm\common;..\..\..\libcpu\arm\cortex-m4;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;board;..\libraries\HAL_Drivers;..\..\..\components\finsh;.;..\..\..\include;..\..\..\components\libc\compilers\common;..\..\..\components\libc\compilers\common\nogcc;..\libraries\MAX32660PeriphDriver\CMSIS\Device\Maxim\MAX32660\Include;..\libraries\MAX32660PeriphDriver\CMSIS\Core\Include;..\libraries\MAX32660PeriphDriver\Include;..\..\..\examples\utest\testcases\kernel
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: application.c
  group CPU
    ../../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
  group DeviceDrivers
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/src/: ringblk_buf.c dataqueue.c waitqueue.c ringbuffer.c completion.c pipe.c workqueue.c
  group Drivers
    ../libraries/MAX32660PeriphDriver/CMSIS/Device/Maxim/MAX32660/Source/ARM/: startup_max32660.s
    board/: board.c
    ../libraries/HAL_Drivers/: drv_gpio.c drv_uart.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c cmd.c
  group Kernel
    ../../../src/: irq.c timer.c scheduler.c idle.c mem.c device.c object.c kservice.c ipc.c mempool.c clock.c components.c thread.c
  group Libraries
    ../libraries/MAX32660PeriphDriver/Source/: tmr.c mxc_sys.c mxc_assert.c nvic_table.c tmr_utils.c mxc_pins.c icc.c uart.c mxc_delay.c lp.c rtc.c mxc_lock.c gpio.c
    ../libraries/MAX32660PeriphDriver/CMSIS/Device/Maxim/MAX32660/Source/: system_max32660.c
