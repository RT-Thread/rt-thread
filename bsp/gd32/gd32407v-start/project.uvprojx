# Keil uVision project project.uvprojx, settings and files
target rt-thread_gd32f4xx (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: GD32F407VK GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0300000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rtthread-gd32f4xx
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=4 uC99=1 v6Lang=1 v6LangP=1
  c define: GD3232F407xx, USE_STDPERIPH_DRIVER, __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND
  c include: applications;.;..\..\..\libcpu\arm\common;..\..\..\libcpu\arm\cortex-m4;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;board;..\libraries\HAL_Drivers;..\..\..\components\finsh;.;..\..\..\include;..\..\..\components\libc\compilers\common;..\..\..\components\libc\compilers\common\none-gcc;..\libraries\GD32F4xx_HAL\CMSIS\GD\GD32F4xx\Include;..\libraries\GD32F4xx_HAL\CMSIS;..\libraries\GD32F4xx_HAL\GD32F4xx_standard_peripheral\Include;..\..\..\examples\utest\testcases\kernel
  memory RVCT4: ROM 0x8000000 size 0x300000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Applications
    applications/: main.c
  group CPU
    ../../../libcpu/arm/common/: showmem.c backtrace.c div0.c
    ../../../libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
  group DeviceDrivers
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/src/: ringblk_buf.c pipe.c waitqueue.c ringbuffer.c completion.c workqueue.c dataqueue.c
  group Drivers
    ../libraries/GD32F4xx_HAL/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f4xx.s
    board/: board.c
    ../libraries/HAL_Drivers/: drv_gpio.c drv_usart.c
  group finsh
    ../../../components/finsh/: finsh_node.c finsh_parser.c cmd.c msh.c finsh_vm.c shell.c finsh_var.c finsh_compiler.c finsh_heap.c finsh_ops.c finsh_error.c finsh_token.c finsh_init.c
  group Kernel
    ../../../src/: thread.c timer.c clock.c components.c device.c scheduler.c mem.c mempool.c idle.c ipc.c kservice.c irq.c object.c
  group libc
    ../../../components/libc/compilers/common/: time.c
  group Libraries
    ../libraries/GD32F4xx_HAL/GD32F4xx_standard_peripheral/Source/: gd32f4xx_syscfg.c gd32f4xx_exti.c gd32f4xx_gpio.c gd32f4xx_rcu.c gd32f4xx_misc.c gd32f4xx_usart.c
    ../libraries/GD32F4xx_HAL/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
software components: CMSIS:CORE 5.0.1
