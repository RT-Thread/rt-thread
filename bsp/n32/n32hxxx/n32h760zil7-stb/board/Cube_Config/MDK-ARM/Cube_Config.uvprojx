# Keil uVision project Cube_Config.uvprojx, settings and files
target Cube_Config (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32H760xIx7 Nationstech
  pack: Nationstech.N32H76x_DFP.1.1.0
  cpu: IRAM1(0x24000000,0x100000) IROM1(0x15000000,0x1E0000) CPUTYPE(Cortex-M7) FPU2 CLOCK(12000000) ELITTLE
  output: Cube_Config +hex
  AfterMake: fromelf --bin --output=.\bin\Cube_Config.bin .\Objects\Cube_Config.axf
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: N32H76x, USE_STDPERIPH_DRIVER,CORE_CM7,USING_TCM
  c include: ..\USER\inc;..\Driver\CMSIS\core;..\Driver\CMSIS\device;..\Driver\n32h76x_78x_std_periph_driver\inc;..\Driver\n32h76x_78x_periph_app\inc
  library: MicroLIB
  memory RVCT4: ROM 0x15000000 size 0x1E0000
  memory RVCT9: RAM 0x24000000 size 0x100000
  scatter file: .\Cube_Config_CM7.sct
  group STARTUP
    ../Driver/CMSIS/device/startup/: startup_N32H76x.s
  group CMSIS
    ../Driver/CMSIS/device/: system_n32h76x_78x.c
  group USER
    ../USER/src/: main.c n32h76x_78x_it.c n32h76x_78x_cfg.c
  group FWLB
    ../Driver/n32h76x_78x_std_periph_driver/src//: n32h76x_78x_rcc.c misc.c n32h76x_78x_dma.c n32h76x_78x_gpio.c n32h76x_78x_usart.c n32h76x_78x_pwr.c n32h76x_78x_dmamux.c n32h76x_78x_mdma.c
