# IAR project project.ewp, settings and files
configuration rtthread (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407ZG ST STM32F407ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: __RTTHREAD__; RT_USING_DLIBC
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: Libraries\CMSIS\DeviceSupport; ..\..\components\libc\compilers\common\nogcc; ..\..\include; ..\..\components\libc\compilers\dlib; Libraries\SWM320_StdPeriph_Driver; drivers; ..\..\components\libc\compilers\common; .; applications; ..\..\libcpu\arm\cortex-m4; ..\..\examples\utest\testcases\kernel; ..\..\components\drivers\include; ..\..\libcpu\arm\common; ..\..\components\finsh; Libraries\CMSIS\CoreSupport
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../../rtthread.bin
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: drivers\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: main.c
  group CPU
    ../../libcpu/arm/common/: div0.c showmem.c backtrace.c
    ../../libcpu/arm/cortex-m4/: cpuport.c context_iar.S
  group DeviceDrivers
    ../../components/drivers/misc/: pin.c
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/src/: ringbuffer.c pipe.c workqueue.c ringblk_buf.c dataqueue.c waitqueue.c completion.c
  group Drivers
    drivers/: drv_gpio.c drv_uart.c board.c
  group Finsh
    ../../components/finsh/: shell.c msh.c cmd.c
  group Kernel
    ../../src/: memheap.c thread.c clock.c scheduler.c object.c components.c timer.c irq.c ipc.c kservice.c device.c mempool.c idle.c
  group libc
    ../../components/libc/compilers/common/: stdlib.c time.c
    ../../components/libc/compilers/dlib/: syscall_open.c syscall_read.c libc.c environ.c syscall_mem.c syscall_write.c syscall_lseek.c syscalls.c syscall_close.c syscall_remove.c stdio.c
  group Libraries
    Libraries/SWM320_StdPeriph_Driver/: SWM320_sdio.c SWM320_flash.c SWM320_wdt.c SWM320_exti.c SWM320_can.c SWM320_lcd.c SWM320_norflash.c SWM320_dma.c SWM320_sram.c SWM320_crc.c SWM320_sdram.c SWM320_rtc.c SWM320_gpio.c SWM320_i2c.c SWM320_timr.c SWM320_pwm.c SWM320_adc.c SWM320_spi.c SWM320_uart.c SWM320_port.c
    Libraries/CMSIS/DeviceSupport/: system_SWM320.c
    Libraries/CMSIS/DeviceSupport/startup/iar/: startup_SWM320.s
