# Keil uVision project project.uvproj, settings and files
target RT-Thread FM3 (ARM-ADS)
  device: MB9BF500R Fujitsu Semiconductors
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x00000000-0x0003FFFF) CLOCK(4000000) CPUTYPE("Cortex-M3")
  output: rtthread-fm3
  c flags: Optim=1
  c include: ..\CMSIS;.;..\..\..\libcpu\arm\fm3;..\..\..\include;..\..\..\components\rtgui\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Startup
    ./: application.c board.c startup.c adc.c cpuusage.c key.c lcd.c led.c info.c
  group FM3
    ../../../libcpu/arm/cortex-m3/: context_rvds.S cpuport.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_mb9bf50x.c start_rvds.S
  group Kernel
    ../../../src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c module.c object.c rtm.c scheduler.c slab.c thread.c timer.c
