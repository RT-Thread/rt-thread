# Keil uVision project project.uvproj, settings and files
target rt-thread (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_HAL_DRIVER, __CLK_TCK=RT_TICK_PER_SECOND, __RTTHREAD__, STM32F103xE
  c include: applications;..\..\..\libcpu\arm\common;..\..\..\libcpu\arm\cortex-m3;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;board;board\CubeMX_Config\Inc;board\ports;..\libraries\HAL_Drivers;..\libraries\HAL_Drivers\config;..\..\..\components\finsh;.;..\..\..\include;..\..\..\components\libc\compilers\common;..\..\..\components\libc\compilers\common\nogcc;..\libraries\STM32F1xx_HAL\CMSIS\Device\ST\STM32F1xx\Include;..\libraries\STM32F1xx_HAL\STM32F1xx_HAL_Driver\Inc;..\libraries\STM32F1xx_HAL\CMSIS\Include;..\..\..\examples\utest\testcases\kernel
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: nrf24l01_init.c main.c
  group CPU
    ../../../libcpu/arm/common/: div0.c showmem.c backtrace.c
    ../../../libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
  group DeviceDrivers
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/src/: ringbuffer.c dataqueue.c waitqueue.c ringblk_buf.c workqueue.c pipe.c completion.c
  group Drivers
    ../libraries/STM32F1xx_HAL/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xe.s
    board/CubeMX_Config/Src/: stm32f1xx_hal_msp.c
    board/: board.c
    ../libraries/HAL_Drivers/: drv_gpio.c drv_usart.c drv_common.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c cmd.c
  group Kernel
    ../../../src/: ipc.c mempool.c idle.c device.c mem.c components.c irq.c timer.c kservice.c scheduler.c clock.c thread.c object.c
  group libc
    ../../../components/libc/compilers/common/: time.c
  group Libraries
    ../libraries/STM32F1xx_HAL/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_pwr.c stm32f1xx_hal_dma.c stm32f1xx_hal_crc.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_cec.c stm32f1xx_hal_usart.c stm32f1xx_hal_gpio.c
    ../libraries/STM32F1xx_HAL/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
