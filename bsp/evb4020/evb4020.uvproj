# Keil uVision project evb4020.uvproj, settings and files
target EVB4020 (ARM-ADS)
  device: ARM7 (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM7TDMI)
  output: evb4020
  c flags: Optim=1 wLevel=2
  c misc: -g
  c include: .\src;..\..\include;..\..\finsh;..\..\filesystem;..\..\components\dfs\include;..\..\components\finsh;..\..\components\dfs;..\..\components\net\lwip\src\arch\include;..\..\components\net\lwip\src\include;..\..\components\net\lwip\src;..\..\components\net\lwip\src\include\ipv4;..\..\components\net\lwip\src\include\netif;..\..\components\net\lwip\src\include\lwip
  asm define: RAM_INTVEC REMAP
  memory RVCT1: ROM 0x20000000 size 0x200000
  memory RVCT6: RAM 0x30000000 size 0x200000
  memory RVCT9: RAM 0x0 size 0x4000000
  scatter file: evb4020.sct
  link misc: --verbose --list=out.txt
  group STARTUP
    ./src/: startup.c application.c export.c
  group KERNEL
    ../../src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c slab.c thread.c timer.c
  group SEP4020
    ../../libcpu/arm/sep4020/: context_rvds.S start_rvds.S stack.c trap.c interrupt.c cpu.c
    ./src/: board.c serial.c sdcard.c dm9161.c
  group ARM
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
  group FileSystem
    ../../components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
    ../../components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
  group FINSH
    ../../components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c shell.c symbol.c
  group LWIP
    ../../components/net/lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../components/net/lwip/src/arch/: sys_arch.c sys_arch_init.c
    ../../components/net/lwip/src/core/: dhcp.c dns.c init.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
    ../../components/net/lwip/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../components/net/lwip/src/core/snmp/: asn1_dec.c asn1_enc.c mib_structs.c mib2.c msg_in.c msg_out.c
    ../../components/net/lwip/src/netif/: etharp.c ethernetif.c loopif.c slipif.c
    ../../components/net/lwip/src/netif/ppp/: auth.c chap.c chpms.c fsm.c ipcp.c lcp.c magic.c md5.c pap.c ppp.c ppp_oe.c randm.c vj.c
    ../../components/net/apps/: ping.c
