# Keil uVision project project.uvprojx, settings and files
target rtthread-rtp (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: rtthread +hex
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  AfterMake: fromelf --text -c "$L@L.axf" --output "$L@L.txt"
  c flags: Optim=3 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __STDC_LIMIT_MACROS, __CLK_TCK=RT_TICK_PER_SECOND, RT_USING_ARMLIBC, __RTTHREAD__, RT_USING_LIBC
  c include: ..\..\..\components\libc\posix\io\eventfd;..\..\..\components\finsh;..\..\..\components\libc\posix\ipc;..\..\..\components\drivers\smp_call;..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\components\utilities\ulog;..\..\..\examples\utest\testcases\lwp;..\..\..\examples\utest\testcases\mm;..\..\..\examples\utest\testcases\tmpfs;..\..\..\components\libc\posix\io\epoll;..\libraries\nu_packages\Demo;..\libraries\nu_packages\NuUtils\inc;..\..\..\libcpu\arm\common;..\..\..\include;..\libraries\nu_packages\TPC;..\..\..\components\drivers\include;..\libraries\ma35\Device\Nuvoton\MA35D1\Include;..\..\..\components\drivers\phy;..\libraries\ma35\CMSIS\Include;.;..\..\..\components\utilities\utest;..\..\..\libcpu\arm\cortex-m4;..\libraries\ma35\rtt_port;..\..\..\examples\utest\testcases\smp_call;..\..\..\examples\utest\testcases\drivers\ipc;..\..\..\examples\utest\testcases\utest;..\..\..\components\libc\compilers\common\include;..\..\..\components\drivers\include;..\..\..\examples\utest\testcases\kernel;..\..\..\components\drivers\include;board;board\nutool_pincfg;..\..\..\components\libc\posix\io\poll;..\libraries\ma35\StdDriver\inc;..\libraries\ma35\libcpu\arm\cortex-m4;..\..\..\components\drivers\include;applications;..\..\..\examples\utest\testcases\kernel\smp;..\..\..\components\libc\compilers\common\extension;..\..\..\components\drivers\include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Applications
    applications/: main.c mnt.c
  group board
    board/nutool_pincfg/: nutool_pincfg.c
    board/: board_dev.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group CPU
    ../libraries/ma35/libcpu/arm/cortex-m4/: interrupt.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/pin/: dev_pin.c
    ../../../components/drivers/serial/: dev_serial.c
  group Drivers
    ../libraries/ma35/Device/Nuvoton/MA35D1/Source/ARM/: startup_ma35d1_subm.s
    ../libraries/ma35/Device/Nuvoton/MA35D1/Source/: system_ma35d1_subm.c
    ../libraries/ma35/rtt_port/: drv_adc.c drv_canfd.c drv_ccap.c drv_common_aarch32.c drv_common_subm.c drv_disp.c drv_eadc.c drv_ecap.c drv_epwm.c drv_epwm_capture.c drv_gpio.c drv_hwsem.c drv_i2c.c drv_i2s.c drv_pdma.c drv_qei.c drv_qspi.c drv_rtc.c drv_rtp.c drv_scuart.c drv_sdio.c drv_softi2c.c drv_spi.c drv_spii2s.c drv_ssmcc.c drv_sspcc.c drv_sys.c drv_sys_i2c0.c drv_timer.c drv_tpwm.c drv_uart.c drv_umctl2.c drv_usbhost.c drv_wdt.c drv_whc.c nu_clock_init.c
  group Finsh
    ../../../components/finsh/: cmd.c msh_parse.c shell.c msh.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    ../../../src/klibc/: kerrno.c kstdio.c rt_vsnprintf_tiny.c kstring.c rt_vsscanf.c
  group libcpu
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group Libraries
    ../libraries/ma35/StdDriver/src/: nu_i2c.c nu_wdt.c nu_clk.c nu_timer.c nu_pdma.c nu_wwdt.c nu_sdh.c nu_epwm.c nu_qspi.c nu_disp.c nu_timer_pwm.c nu_ssmcc.c nu_adc.c nu_spi.c nu_kpi.c nu_gpio.c nu_rtc.c nu_i2s.c nu_eadc.c nu_whc.c nu_qei.c nu_canfd.c nu_sys.c nu_ccap.c nu_sspcc.c nu_scuart.c nu_ebi.c nu_sc.c nu_uart.c nu_ecap.c
  group nu_pkgs_demo
    ../libraries/nu_packages/Demo/: wormhole_demo.c atdev_utils.c usbd_cdc_vcom_echo.c ccap_demo.c smp_demo.c ccap_saver.c usbd_hid_dance_mouse.c slcd_show_tick.c hwsem_counter.c
  group UTest
    ../../../components/utilities/utest/: utest.c TC_uassert.c
  group utestcases
    ../../../examples/utest/testcases/kernel/: mem_tc.c
    ../../../examples/utest/testcases/utest/: pass_tc.c
  group Utilities
    ../../../components/utilities/ulog/: ulog.c
    ../../../components/utilities/ulog/backend/: console_be.c
