# IAR project project.ewp, settings and files
configuration rt-thread (ARM, debug)
  General.OGChipSelectEditMenu: STM32L552ZE ST STM32L552ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; STM32H563xx; __RTTHREAD__; USE_HAL_DRIVER; __RT_IPC_SOURCE__; __RT_KERNEL_SOURCE__
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\components\libc\posix\ipc; ..\..\..\components\drivers\smp_call; .; ..\..\..\components\drivers\phy; ..\..\..\components\libc\posix\io\eventfd; ..\..\..\components\drivers\include; ..\libraries\STM32H5xx_HAL\CMSIS\Device\ST\STM32H5xx\Include; ..\libraries\HAL_Drivers\CMSIS\Include; ..\libraries\HAL_Drivers\drivers; ..\..\..\libcpu\arm\cortex-m33; ..\..\..\libcpu\arm\common; ..\libraries\HAL_Drivers; ..\libraries\STM32H5xx_HAL\STM32H5xx_HAL_Driver\Inc; ..\..\..\include; ..\..\..\components\libc\posix\io\epoll; ..\..\..\components\libc\compilers\common\extension; ..\..\..\components\libc\compilers\common\include; board\CubeMX_Config\Inc; ..\libraries\HAL_Drivers\drivers\config; ..\..\..\components\libc\posix\io\poll; ..\..\..\components\drivers\spi; ..\..\..\components\libc\compilers\common\extension\fcntl\octal; ..\..\..\components\finsh; applications; board
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../../rtthread.bin
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: main.c
  group Compiler
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/i2c/: dev_i2c_bit_ops.c dev_i2c_core.c dev_i2c_dev.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/misc/: adc.c rt_drv_pwm.c
    ../../../components/drivers/pin/: dev_pin.c
    ../../../components/drivers/serial/: dev_serial.c
    ../../../components/drivers/spi/: dev_spi.c dev_spi_core.c
  group Drivers
    ../libraries/HAL_Drivers/drivers/: drv_adc.c drv_gpio.c drv_spi.c drv_usart.c
    ../libraries/HAL_Drivers/: drv_common.c
    ../libraries/STM32H5xx_HAL/CMSIS/Device/ST/STM32H5xx/Source/Templates/iar/: startup_stm32h563xx.s
    board/CubeMX_Config/Src/: stm32h5xx_hal_msp.c
    board/: board.c
  group Finsh
    ../../../components/finsh/: msh_parse.c cmd.c shell.c msh.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    ../../../src/klibc/: rt_vsnprintf_tiny.c rt_vsscanf.c kstdio.c kerrno.c kstring.c
  group libcpu
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m33/: context_iar.S cpuport.c syscall_iar.S trustzone.c
  group Libraries
    ../libraries/STM32H5xx_HAL/STM32H5xx_HAL_Driver/Src/: stm32h5xx_hal_spi_ex.c stm32h5xx_hal_pwr.c stm32h5xx_hal_dma_ex.c stm32h5xx_hal_exti.c stm32h5xx_hal_rng.c stm32h5xx_hal_crc.c stm32h5xx_hal_comp.c stm32h5xx_hal_rcc_ex.c stm32h5xx_hal.c stm32h5xx_hal_tim.c stm32h5xx_hal_rcc.c stm32h5xx_hal_gpio.c stm32h5xx_hal_uart_ex.c stm32h5xx_hal_pwr_ex.c stm32h5xx_hal_cryp.c stm32h5xx_hal_adc.c stm32h5xx_hal_i2c_ex.c stm32h5xx_hal_dma.c stm32h5xx_hal_crc_ex.c stm32h5xx_hal_lptim.c stm32h5xx_hal_usart.c stm32h5xx_hal_adc_ex.c stm32h5xx_hal_icache.c stm32h5xx_hal_i2c.c stm32h5xx_hal_usart_ex.c stm32h5xx_hal_uart.c stm32h5xx_hal_cortex.c stm32h5xx_hal_spi.c stm32h5xx_hal_tim_ex.c stm32h5xx_hal_cryp_ex.c
    ../libraries/STM32H5xx_HAL/CMSIS/Device/ST/STM32H5xx/Source/Templates/: system_stm32h5xx.c
