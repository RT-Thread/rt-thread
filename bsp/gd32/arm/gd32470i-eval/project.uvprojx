# Keil uVision project project.uvprojx, settings and files
target rt-thread (ARM-ADS)
  device: GD32F470ZG GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.3
  cpu: IRAM(0x20000000,0x070000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: __STDC_LIMIT_MACROS, __CLK_TCK=RT_TICK_PER_SECOND, USE_STDPERIPH_DRIVER, __RTTHREAD__, RT_USING_LIBC, RT_USING_ARMLIBC, GD32F470
  c include: board;..\..\..\..\components\drivers\include;..\libraries\gd32_drivers;..\..\..\..\components\finsh;packages\gd32-arm-cmsis-latest\GD32F4xx\GD\GD32F4xx\Include;..\..\..\..\components\libc\compilers\common\include;..\..\..\..\include;..\..\..\..\components\drivers\include;..\..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\..\components\libc\posix\io\epoll;..\..\..\..\components\drivers\phy;.;packages\gd32-arm-cmsis-latest\GD32F4xx;..\..\..\..\components\libc\posix\io\eventfd;..\..\..\..\components\drivers\include;..\..\..\..\components\drivers\include;..\..\..\..\components\libc\posix\ipc;..\..\..\..\libcpu\arm\common;packages\gd32-arm-series-latest\GD32F4xx\GD32F4xx_standard_peripheral\Include;..\..\..\..\components\drivers\include;..\..\..\..\components\drivers\smp_call;..\..\..\..\components\libc\compilers\common\extension;..\..\..\..\libcpu\arm\cortex-m4;board\ports;..\..\..\..\components\libc\posix\io\poll;applications
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x70000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Applications
    applications/: main.c
  group Compiler
    ../../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../../components/drivers/core/: device.c
    ../../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../components/drivers/pin/: dev_pin.c
    ../../../../components/drivers/serial/: dev_serial.c
  group Drivers
    board/: board.c
    ../libraries/gd32_drivers/: drv_gpio.c drv_usart.c
  group Finsh
    ../../../../components/finsh/: cmd.c shell.c msh_parse.c msh.c
  group Kernel
    ../../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    ../../../../src/klibc/: rt_vsscanf.c kstring.c rt_vsnprintf_tiny.c kerrno.c kstdio.c
  group libcpu
    ../../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group Libraries
    packages/gd32-arm-cmsis-latest/GD32F4xx/GD/GD32F4xx/Source/ARM/: startup_gd32f4xx.s
    packages/gd32-arm-cmsis-latest/GD32F4xx/GD/GD32F4xx/Source/: system_gd32f4xx.c
    packages/gd32-arm-series-latest/GD32F4xx/GD32F4xx_standard_peripheral/Source/: gd32f4xx_dma.c gd32f4xx_exti.c gd32f4xx_gpio.c gd32f4xx_misc.c gd32f4xx_rcu.c gd32f4xx_syscfg.c gd32f4xx_usart.c
software components: CMSIS:CORE 5.5.0
