# Keil uVision project project.uvprojx, settings and files
target rtthread-lpc55s36 (6160000::V6.16::ARMCLANG)
  device: LPC55S36JBD100 NXP
  pack: NXP.LPC55S36_DFP.13.0.0
  cpu: IRAM(0x10000000,0x03d800) IRAM2(0x20000000,0x01c000) IROM(0x03000000,0x020000) IROM2(0x13000000,0x020000) XRAM(0x04000000,0x4000) XRAM2(0x14000000,0x4000) XRAM3(0x30000000,0x01c000) XROM(0x00000000,0x03d800) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: rtthread
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=3
  c define: RT_USING_LIBC, __STDC_LIMIT_MACROS, __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND, RT_USING_ARMLIBC, DEBUG
  c misc: --target=arm-arm-none-eabi
  c include: ..\..\..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\Libraries\LPC55S36\LPC55S36\drivers;..\Libraries\drivers;..\..\..\..\..\components\libc\posix\io\epoll;..\..\..\..\..\components\libc\posix\io\eventfd;..\..\..\..\..\components\drivers\include;..\Libraries\LPC55S36\components\codec;..\..\..\..\..\components\libc\posix\ipc;..\..\..\..\..\components\drivers\smp_call;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\drivers\phy;..\Libraries\LPC55S36\middleware\sdmmc\port;..\Libraries\LPC55S36\middleware\sdmmc\inc;..\Libraries\LPC55S36\LPC55S36;applications;.;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\drivers\include;..\..\..\..\..\include;..\..\..\..\..\components\finsh;..\..\..\..\..\libcpu\arm\common;..\..\..\..\..\components\libc\compilers\common\extension;board\MCUX_Config\board;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\libc\compilers\common\include;board;..\Libraries\CMSIS\Core\Include;..\..\..\..\..\components\libc\posix\io\poll;..\..\..\..\..\libcpu\arm\cortex-m33
  asm misc: -x assembler-with-cpp
  memory RVCT1: ROM 0x0 size 0x3d800
  memory RVCT4: ROM 0x3000000 size 0x20000
  memory RVCT5: ROM 0x13000000 size 0x20000
  memory RVCT6: RAM 0x4000000 size 0x4000
  memory RVCT7: RAM 0x14000000 size 0x4000
  memory RVCT8: RAM 0x30000000 size 0x1c000
  memory RVCT9: RAM 0x10000000 size 0x3d800
  memory RVCT10: RAM 0x20000000 size 0x1c000
  scatter file: .\board\linker_scripts\LPC55S36_flash.scf
  group Applications
    applications/: main.c
  group Compiler
    ../../../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../../../components/drivers/core/: device.c
    ../../../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../../components/drivers/pin/: dev_pin.c
    ../../../../../components/drivers/serial/: dev_serial.c
  group Drivers
    board/MCUX_Config/board/: clock_config.c pin_mux.c
    board/: board.c
    ../Libraries/drivers/: drv_pin.c drv_uart.c
  group Finsh
    ../../../../../components/finsh/: msh_parse.c msh.c cmd.c shell.c
  group Kernel
    ../../../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    ../../../../../src/klibc/: rt_vsnprintf_tiny.c kstring.c kstdio.c kerrno.c rt_vsscanf.c
  group libcpu
    ../../../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../../../libcpu/arm/cortex-m33/: context_rvds.S cpuport.c syscall_rvds.S trustzone.c
  group Libraries
    ../Libraries/LPC55S36/LPC55S36/drivers/: fsl_i2c_dma.c fsl_common_arm.c fsl_sctimer.c fsl_pint.c fsl_dma.c fsl_utick.c fsl_lpadc.c fsl_usart_dma.c fsl_cmp.c fsl_power.c fsl_gint.c fsl_flexcomm.c fsl_inputmux.c fsl_usart.c fsl_i2s_dma.c fsl_mrt.c fsl_clock.c fsl_gpio.c fsl_spi.c fsl_reset.c fsl_wwdt.c fsl_sysctl.c fsl_common.c fsl_i2s.c fsl_spi_dma.c fsl_ostimer.c fsl_crc.c fsl_i2c.c fsl_ctimer.c fsl_anactrl.c
    ../Libraries/LPC55S36/LPC55S36/arm/: startup_LPC55S36.s
    ../Libraries/LPC55S36/LPC55S36/: system_LPC55S36.c
