# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __CLK_TCK=RT_TICK_PER_SECOND, TARGET_IS_TM4C123_RB1, PART_TM4C123GH6PM, __RTTHREAD__, RT_USING_LIBC, RT_USING_ARMLIBC, __STDC_LIMIT_MACROS, rvmdk
  c include: ..\..\components\drivers\spi;libraries\Drivers;..\..\include;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\libc\compilers\common\extension;..\..\components\libc\posix\io\eventfd;libraries\Drivers\config;..\..\components\libc\posix\io\epoll;..\..\components\libc\posix\io\poll;..\..\components\finsh;libraries\TivaWare_C_series\tm4c123_driverlib;libraries\TivaWare_C_series\tm4c123_driverlib\driverlib\inc;board;..\..\components\libc\compilers\common\include;..\..\components\drivers\smp_call;..\..\libcpu\arm\common;..\..\components\drivers\phy;applications;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\drivers\include;libraries\TivaWare_C_series\tm4c123_driverlib\driverlib;..\..\components\net\utest;..\..\components\drivers\include;..\..\libcpu\arm\cortex-m4;..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\components\libc\posix\ipc;.;..\..\components\drivers\include;..\..\components\drivers\include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group CPU
    ../../libcpu/arm/common/: div0.c showmem.c
    ../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../components/drivers/core/: device.c
    ../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../components/drivers/misc/: adc.c rt_drv_pwm.c
    ../../components/drivers/pin/: dev_pin.c
    ../../components/drivers/serial/: dev_serial.c
    ../../components/drivers/spi/: dev_spi.c dev_spi_core.c
  group Drivers
    board/: board.c tm4c123_config.c
    libraries/TivaWare_C_series/tm4c123_driverlib/startup/arm/: startup_rvmdk.S
    libraries/Drivers/: drv_adc.c drv_gpio.c drv_pwm.c drv_spi.c drv_uart.c
  group Finsh
    ../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group Libc
    ../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
  group Libraries
    libraries/TivaWare_C_series/tm4c123_driverlib/src/: sysctl.c systick.c interrupt.c fpu.c cpu.c gpio.c uart.c ssi.c pwm.c adc.c
