# IAR project project.ewp, settings and files
configuration rtthread (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1176xxxA_M7 NXP MIMXRT1176xxxA_M7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 0
  ICCARM.CCDefines: CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; CPU_MIMXRT1176DVMAA_cm7; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=1; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; XIP_EXTERNAL_FLASH=1; ARM_MATH_CM7; USE_SDRAM; ENDIANNESS; USE_RTOS; __RTTHREAD__; __RT_IPC_SOURCE__; __RT_KERNEL_SOURCE__
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ..\libraries\drivers; ..\..\..\..\..\components\legacy\usb\usbhost\core; ..\..\..\..\..\components\libc\posix\io\poll; ..\..\..\..\..\libcpu\arm\common; ..\..\..\..\..\components\drivers\include; .; ..\..\..\..\..\components\net\netdev\include; ..\libraries\MIMXRT1170\MIMXRT1176; board\ports; ..\..\..\..\..\components\libc\compilers\common\include; xip; board; ..\..\..\..\..\components\libc\posix\ipc; ..\..\..\..\..\components\legacy\include; board\MCUX_Config; ..\..\..\..\..\components\legacy\usb\usbhost; ..\..\..\..\..\components\drivers\phy; ..\..\..\..\..\components\finsh; ..\libraries\MIMXRT1170\MIMXRT1176\drivers; ..\libraries\MIMXRT1170\MIMXRT1176\drivers\cm7; ..\..\..\..\..\components\libc\compilers\common\extension\fcntl\octal; ..\..\..\..\..\components\libc\posix\io\epoll; ..\..\..\..\..\components\drivers\smp_call; ..\libraries\MIMXRT1170\CMSIS\Include; applications; ..\..\..\..\..\components\legacy\usb\usbhost\class; ..\..\..\..\..\components\libc\compilers\common\extension; ..\..\..\..\..\components\libc\posix\io\eventfd; ..\..\..\..\..\include; ..\..\..\..\..\libcpu\arm\cortex-m7; ..\..\..\..\..\components\legacy\usb\usbhost\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: template.srec
  ILINK.IlinkOutputFile: rtthread.out
  ILINK.IlinkIcfFile: board\linker_scripts\link_ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Applications
    applications/: mnt.c main.c
  group Compiler
    ../../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../../../components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
  group DeviceDrivers
    ../../../../../components/drivers/core/: device.c
    ../../../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../../components/drivers/phy/: phy.c
    ../../../../../components/drivers/pin/: dev_pin.c
    ../../../../../components/drivers/serial/: dev_serial.c
  group Drivers
    board/MCUX_Config/: clock_config.c pin_mux.c
    board/: board.c dcd.c
    ../libraries/drivers/: drv_common.c drv_gpio.c drv_uart.c drv_usbh.c
    ../libraries/drivers/usb/host/: usb_host_devices.c usb_host_ehci.c usb_host_framework.c usb_host_hci.c
    ../libraries/drivers/usb/phy/: usb_phy.c
  group Finsh
    ../../../../../components/finsh/: msh_parse.c shell.c cmd.c msh.c
  group Kernel
    ../../../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    ../../../../../src/klibc/: kstring.c rt_vsscanf.c kerrno.c rt_vsnprintf_tiny.c kstdio.c
  group libcpu
    ../../../../../libcpu/arm/common/: div0.c showmem.c
    ../../../../../libcpu/arm/cortex-m7/: context_iar.S cpu_cache.c cpuport.c
  group Libraries
    ../libraries/MIMXRT1170/MIMXRT1176/iar/: startup_MIMXRT1176_cm7.s
    ../libraries/MIMXRT1170/MIMXRT1176/drivers/: fsl_dcdc.c generic_list.c fsl_lpuart.c fsl_gpio.c fsl_common.c fsl_pmu.c fsl_os_abstraction_rtthread.c fsl_clock.c fsl_anatop_ai.c fsl_common_arm.c
    ../libraries/MIMXRT1170/MIMXRT1176/: system_MIMXRT1176_cm7.c
    ../libraries/MIMXRT1170/MIMXRT1176/drivers/cm7/: fsl_cache.c
  group rt_usbh
    ../../../../../components/legacy/usb/usbhost/core/: usbhost.c driver.c usbhost_core.c hub.c
  group SAL
    ../../../../../components/net/netdev/src/: netdev.c netdev_ipaddr.c
  group xip
    xip/: fsl_flexspi_nor_boot.c evkmimxrt1170_flexspi_nor_config.c
