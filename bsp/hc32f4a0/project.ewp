# IAR project project.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: RT_USING_DLIBC; _DLIB_FILE_DESCRIPTOR; _DLIB_THREAD_SUPPORT; USE_DDL_DRIVER; HC32F4A0; __DEBUG; __RTTHREAD__
  ICCARM.CCIncludePath2: Libraries\CMSIS\Device\HDSC\HC32F4A0\Include; ..\..\include; Libraries\CMSIS\Include; ..\..\components\libc\compilers\dlib; drivers; ..\..\components\libc\compilers\common; Libraries\HC32F4A0_StdPeriph_Driver\inc; .; applications; ..\..\libcpu\arm\cortex-m4; board; ..\..\components\drivers\include; ..\..\libcpu\arm\common; ..\..\components\dfs\filesystems\devfs; ..\..\components\finsh; ..\..\components\dfs\include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: rtthread.bin
  ILINK.IlinkOutputFile: rtthread.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: __DEBUG; RT_USING_DLIBC; _DLIB_FILE_DESCRIPTOR; _DLIB_THREAD_SUPPORT; USE_DDL_DRIVER; HC32F4A0; __DEBUG; __RTTHREAD__
  group Applications
    applications/: main.c
  group cpu
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../libcpu/arm/cortex-m4/: cpuport.c context_iar.S
  group DeviceDrivers
    ../../components/drivers/misc/: pin.c
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
  group dlib
    ../../components/libc/compilers/dlib/: environ.c libc.c rmtx.c stdio.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c
  group Drivers
    board/: board.c board_config.c
    drivers/: drv_irq.c drv_gpio.c drv_usart.c
  group Filesystem
    ../../components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c poll.c select.c
    ../../components/dfs/filesystems/devfs/: devfs.c
  group finsh
    ../../components/finsh/: shell.c cmd.c msh.c msh_file.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_var.c finsh_vm.c finsh_token.c
  group HC32_StdPeriph
    Libraries/CMSIS/Device/HDSC/HC32F4A0/Source/: system_hc32f4a0.c
    Libraries/HC32F4A0_StdPeriph_Driver/src/: hc32f4a0_clk.c hc32f4a0_dma.c hc32f4a0_efm.c hc32f4a0_gpio.c hc32f4a0_icg.c hc32f4a0_interrupts.c hc32f4a0_pwc.c hc32f4a0_sram.c hc32f4a0_utility.c hc32f4a0_usart.c hc32f4a0_tmr0.c
    Libraries/CMSIS/Device/HDSC/HC32F4A0/Source/IAR/: startup_hc32f4a0.s
  group Kernel
    ../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group libc
    ../../components/libc/compilers/common/: time.c unistd.c
