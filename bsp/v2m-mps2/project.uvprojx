# Keil uVision project project.uvprojx, settings and files
target RT-Thread V2M-MPS2 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: CMSDK_CM7_SP ARM
  pack: Keil.V2M-MPS2_CMx_BSP.1.6.0
  cpu: IRAM(0x20000000,0x00400000) IROM(0x00000000,0x00400000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: rtthread-v2m-mps2
  AfterMake: fromelf --bin !L --output rtthread-mdk.bin
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: RT_USING_ARM_LIBC
  c misc: --library_interface=armcc --library_type=standardlib --diag_suppress=66,1296,186
  c include: applications;.;drivers;packages\micropython;packages\micropython\port;packages\micropython\lib\netutils;..\..\include;..\..\libcpu\arm\cortex-m7;..\..\libcpu\arm\common;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\finsh;..\..\components\libc\compilers\armlibc
  memory RVCT4: ROM 0x0 size 0x400000
  memory RVCT9: RAM 0x20000000 size 0x400000
  scatter file: .\rtthread-v2m-mps2.sct
  link misc: --keep *.o(.rti_fn.*)   --keep *.o(FSymTab) --keep *.o(VSymTab)
  group Applications
    applications/: main.c
  group Drivers
    drivers/: board.c drv_uart.c drv_pin.c
  group MicroPython
    packages/micropython/py/: argcheck.c asmarm.c asmbase.c asmthumb.c asmx64.c asmx86.c asmxtensa.c bc.c binary.c builtinevex.c builtinhelp.c builtinimport.c compile.c emitbc.c emitcommon.c emitglue.c emitinlinethumb.c emitinlinextensa.c emitnative.c formatfloat.c frozenmod.c gc.c lexer.c malloc.c map.c modarray.c modbuiltins.c modcmath.c modcollections.c modgc.c modio.c modmath.c modmicropython.c modstruct.c modsys.c modthread.c moduerrno.c mpprint.c mpstate.c mpy_scheduler.c mpz.c nativeglue.c nlr.c nlrsetjmp.c nlrthumb.c nlrx64.c nlrx86.c nlrxtensa.c obj.c objarray.c objattrtuple.c objbool.c objboundmeth.c objcell.c objclosure.c objcomplex.c objdeque.c objdict.c objenumerate.c objexcept.c objfilter.c objfloat.c objfun.c objgenerator.c objgetitemiter.c objint.c objint_longlong.c objint_mpz.c objlist.c objmap.c objmodule.c objnamedtuple.c objnone.c objobject.c objpolyiter.c objproperty.c objrange.c objreversed.c objset.c objsingleton.c objslice.c objstr.c objstringio.c objstrunicode.c objtuple.c objtype.c objzip.c opmethods.c parse.c parsenum.c parsenumbase.c persistentcode.c pystack.c qstr.c reader.c repl.c runtime.c runtime_utils.c scope.c sequence.c showbc.c smallint.c stackctrl.c stream.c unicode.c vm.c vstr.c warning.c
    packages/micropython/lib/mp-readline/: readline.c
    packages/micropython/lib/utils/: interrupt_char.c printf.c pyexec.c stdout_helpers.c
    packages/micropython/extmod/: machine_i2c.c machine_mem.c machine_pinbase.c machine_pulse.c machine_signal.c machine_spi.c modbtree.c modframebuf.c modubinascii.c moductypes.c moduhashlib.c moduheapq.c modujson.c modurandom.c modure.c moduselect.c modussl_axtls.c modussl_mbedtls.c modutimeq.c moduzlib.c modwebrepl.c modwebsocket.c uos_dupterm.c utime_mphal.c vfs.c vfs_fat.c vfs_fat_diskio.c vfs_fat_file.c vfs_reader.c virtpin.c
    packages/micropython/port/: _frozen_mpy.c file.c help.c machine_pin.c modmachine.c modnetwork.c modpyb.c modrtthread.c moduos.c moduos_file.c modusocket.c modutime.c mpy_main.c rtt_getchar.c uart_core.c
    packages/micropython/lib/netutils/: netutils.c
  group Kernel
    ../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c memheap.c object.c scheduler.c signal.c thread.c timer.c
  group CORTEX-M7
    ../../libcpu/arm/cortex-m7/: cpuport.c context_rvds.S
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
  group DeviceDrivers
    ../../components/drivers/misc/: pin.c
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/src/: completion.c dataqueue.c pipe.c ringbuffer.c waitqueue.c workqueue.c
  group finsh
    ../../components/finsh/: shell.c symbol.c cmd.c msh.c msh_cmd.c msh_file.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_var.c finsh_vm.c finsh_token.c
  group libc
    ../../components/libc/compilers/armlibc/: libc.c libc_syms.c mem_std.c stdio.c stubs.c time.c
software components: CMSIS:CORE 5.0.2, Board Support:Common 2.0.0, Device:Startup 1.0.0
