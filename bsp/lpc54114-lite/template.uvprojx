# Keil uVision project template.uvprojx, settings and files
target rtthread-lpc54114 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC54114J256BD64:M4 NXP
  pack: Keil.LPC54000_DFP.2.6.0
  cpu: IRAM(0x20000000,0x00028000) IRAM2(0x04000000,0x00008000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rtthread-lpc54114
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: CPU_LPC54608, CPU_LPC54608J512ET180=1
  c misc: --library_interface=armcc --library_type=standardlib --diag_suppress=66,1296,186
  c include: .
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x28000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: .\drivers\linker_scripts\link.scf
  link misc: --keep *.o(.rti_fn.*)   --keep *.o(FSymTab) --keep *.o(VSymTab)
