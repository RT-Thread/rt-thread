# Keil uVision project project.uvprojx, settings and files
target rtthread (6190000::V6.19::ARMCLANG)
  device: STM32U585AIIxQ STMicroelectronics
  pack: Keil.STM32U5xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00040000) IRAM2(0x20040000,0x00080000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: __STDC_LIMIT_MACROS, STM32U575xx, USE_HAL_DRIVER, RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND, __RTTHREAD__, RT_USING_ARMLIBC
  c include: ..\..\..\components\drivers\include;..\..\..\libcpu\arm\common;..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\components\drivers\include;..\libraries\HAL_Drivers\config;..\..\..\components\drivers\include;..\libraries\STM32U5xx_HAL\CMSIS\Device\ST\STM32U5xx\Include;board;.;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\libc\posix\io\stdio;..\libraries\STM32U5xx_HAL\STM32U5xx_HAL_Driver\Inc;..\..\..\libcpu\arm\cortex-m33;..\..\..\include;..\..\..\components\drivers\include;..\..\..\components\libc\compilers\common\extension;..\..\..\components\finsh;..\libraries\HAL_Drivers;..\..\..\components\libc\compilers\common\include;..\..\..\components\libc\posix\io\poll;applications;..\libraries\HAL_Drivers\CMSIS\Include;..\..\..\components\drivers\spi;board\CubeMX_Config\Inc;..\..\..\components\libc\posix\ipc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x20040000 size 0x80000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdio.c cstdlib.c cstring.c ctime.c cwchar.c
  group CPU
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m33/: context_rvds.S cpuport.c syscall_rvds.S trustzone.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/i2c/: i2c-bit-ops.c i2c_core.c i2c_dev.c
    ../../../components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/misc/: adc.c pin.c rt_drv_pwm.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/spi/: spi_core.c spi_dev.c
  group Drivers
    ../libraries/HAL_Drivers/: drv_adc.c drv_common.c drv_gpio.c drv_spi.c drv_usart.c
    ../libraries/STM32U5xx_HAL/CMSIS/Device/ST/STM32U5xx/Source/Templates/arm/: startup_stm32u585xx.s
    board/CubeMX_Config/Src/: stm32u5xx_hal_msp.c
    board/: board.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../../src/: clock.c components.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_up.c thread.c timer.c
  group Libraries
    ../libraries/STM32U5xx_HAL/STM32U5xx_HAL_Driver/Src/: stm32u5xx_hal_uart.c stm32u5xx_hal.c stm32u5xx_hal_spi.c stm32u5xx_hal_crc.c stm32u5xx_hal_spi_ex.c stm32u5xx_hal_icache.c stm32u5xx_hal_uart_ex.c stm32u5xx_hal_dma.c stm32u5xx_hal_usart.c stm32u5xx_hal_pwr.c stm32u5xx_hal_rcc.c stm32u5xx_hal_gpio.c stm32u5xx_hal_rng.c stm32u5xx_hal_tim.c stm32u5xx_hal_cortex.c stm32u5xx_hal_ospi.c stm32u5xx_hal_cryp.c stm32u5xx_hal_crc_ex.c stm32u5xx_hal_lptim.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_i2c.c stm32u5xx_hal_usart_ex.c stm32u5xx_hal_cryp_ex.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_comp.c stm32u5xx_hal_i2c_ex.c stm32u5xx_hal_adc_ex.c stm32u5xx_hal_tim_ex.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal_adc.c stm32u5xx_hal_exti.c
    ../libraries/STM32U5xx_HAL/CMSIS/Device/ST/STM32U5xx/Source/Templates/: system_stm32u5xx.c
