# Keil uVision project project.uvprojx, settings and files
target rtthread (ARM-ADS)
  device: Nuvoton_ARM9_Series Nuvoton
  output: rtthread +hex
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __RTTHREAD__, RT_USING_ARM_LIBC, __CLK_TCK=RT_TICK_PER_SECOND
  c misc: --c99
  c include: applications;.;board;..\..\..\components\libc\compilers\common;..\..\..\components\libc\compilers\common\nogcc;..\..\..\libcpu\arm\common;..\..\..\libcpu\arm\arm926;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\hwcrypto;.;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\spi;..\..\..\components\drivers\include;..\..\..\components\drivers\spi\sfud\inc;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\libraries\nuc980\rtt_port;packages\fal-latest\inc;..\..\..\components\dfs\include;..\..\..\components\dfs\filesystems\devfs;..\..\..\components\dfs\filesystems\elmfat;..\..\..\components\finsh;.;..\..\..\include;..\libraries\nuc980\Driver\Include;..\..\..\components\net\lwip-2.1.2\src;..\..\..\components\net\lwip-2.1.2\src\include;..\..\..\components\net\lwip-2.1.2\src\arch\include;..\..\..\components\net\lwip-2.1.2\src\include\netif;packages\netutils-v1.3.1\ntp;packages\netutils-v1.3.1\tftp;.;..\libraries\nu_packages\Demo;..\libraries\nuc980\UsbHostLib\inc;..\libraries\nu_packages\NuUtils\inc;packages\optparse-latest;..\..\..\components\libc\posix\io;..\..\..\components\libc\posix\io\poll;..\..\..\components\libc\posix\ipc;packages\ramdisk-latest\inc;..\..\..\components\drivers\usb\usbdevice;..\..\..\components\drivers\usb\usbhost;..\..\..\components\drivers\usb\usbhost\class;..\..\..\components\drivers\usb\usbhost\core;..\..\..\components\drivers\usb\usbhost\include;..\..\..\components\drivers\include;..\..\..\components\net\netdev\include;..\..\..\components\net\sal_socket\include;..\..\..\components\net\sal_socket\include\socket;..\..\..\components\net\sal_socket\impl;..\..\..\components\net\sal_socket\include\dfs_net;..\..\..\components\net\sal_socket\include\socket\sys_socket;..\..\..\components\utilities\utest;..\..\..\examples\utest\testcases\kernel
  memory RVCT1: ROM 0x20000000 size 0x800000
  memory RVCT4: ROM 0x100000 size 0x8000
  memory RVCT6: RAM 0x20800000 size 0x1800000
  memory RVCT9: RAM 0x200000 size 0x1000
  memory RVCT10: RAM 0x300000 size 0x1000
  scatter file: .\linking_scripts\nuc980.sct
  group Applications
    applications/: main.c mnt.c
  group board
    board/: nu_pin_init.c board_dev.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c libc_syms.c
    ../../../components/libc/compilers/common/: time.c stdlib.c
  group CPU
    ../../../libcpu/arm/common/: backtrace.c showmem.c div0.c
    ../../../libcpu/arm/arm926/: context_rvds.S cpuport.c machine.c start_rvds.S trap.c stack.c mmu.c
  group DeviceDrivers
    ../../../components/drivers/can/: can.c
    ../../../components/drivers/cputime/: cputime.c
    ../../../components/drivers/hwcrypto/: hw_symmetric.c hwcrypto.c hw_rng.c hw_hash.c
    ../../../components/drivers/hwtimer/: hwtimer.c
    ../../../components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    ../../../components/drivers/misc/: adc.c pin.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    ../../../components/drivers/spi/: spi_core.c spi_dev.c qspi_core.c spi_flash_sfud.c
    ../../../components/drivers/src/: pipe.c dataqueue.c workqueue.c completion.c waitqueue.c ringblk_buf.c ringbuffer.c
    ../../../components/drivers/watchdog/: watchdog.c
  group Drivers
    ../libraries/nuc980/rtt_port/: drv_sys.c drv_uart.c drv_wdt.c drv_rtc.c drv_etimer.c drv_usbhost.c drv_qspi.c drv_usbd.c drv_pdma.c drv_sdh.c drv_can.c drv_pwm.c drv_common.c drv_gpio.c drv_spi.c drv_crypto.c drv_etimer_capture.c drv_systick.c drv_softi2c.c drv_i2c.c drv_scuart.c drv_adc.c drv_i2s.c drv_ebi.c drv_emac.c
  group fal
    packages/fal-latest/src/: fal_flash.c fal_rtt.c fal.c fal_partition.c
    packages/fal-latest/samples/porting/: fal_flash_sfud_port.c
  group Filesystem
    ../../../components/dfs/src/: dfs_posix.c dfs_fs.c dfs.c dfs_file.c
    ../../../components/dfs/filesystems/devfs/: devfs.c
    ../../../components/dfs/filesystems/elmfat/: ff.c ffunicode.c dfs_elm.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c msh_file.c cmd.c
  group Kernel
    ../../../src/: components.c object.c idle.c irq.c kservice.c mem.c mempool.c device.c clock.c scheduler.c timer.c memheap.c ipc.c signal.c thread.c
  group Libraries
    ../libraries/nuc980/Driver/Source/: nu_scuart.c nu_wdt.c nu_uart.c nu_crypto.c nu_i2s.c nu_i2c.c nu_ebi.c nu_etimer.c nu_cap.c nu_spi.c nu_sys.c nu_gpio.c nu_can.c nu_wwdt.c nu_emac.c nu_pdma.c nu_rtc.c nu_qspi.c nu_sdh.c nu_usbd.c
  group lwIP
    ../../../components/net/lwip-2.1.2/src/api/: netdb.c sockets.c netifapi.c tcpip.c netbuf.c api_lib.c err.c api_msg.c if_api.c
    ../../../components/net/lwip-2.1.2/src/core/: ip.c netif.c sys.c altcp_alloc.c init.c memp.c raw.c tcp_out.c inet_chksum.c stats.c altcp.c tcp_in.c dns.c timeouts.c udp.c altcp_tcp.c pbuf.c def.c tcp.c
    ../../../components/net/lwip-2.1.2/src/core/ipv4/: autoip.c ip4_addr.c dhcp.c etharp.c ip4.c ip4_frag.c icmp.c igmp.c
    ../../../components/net/lwip-2.1.2/src/netif/: ethernet.c ethernetif.c lowpan6.c
    ../../../components/net/lwip-2.1.2/src/arch/: sys_arch.c
    ../../../components/net/lwip-2.1.2/src/apps/ping/: ping.c
  group NetUtils
    packages/netutils-v1.3.1/iperf/: iperf.c
    packages/netutils-v1.3.1/ntp/: ntp.c
    packages/netutils-v1.3.1/tftp/: tftp_server.c tftp_xfer.c tftp_client.c tftp_port.c
  group nu_pkgs_demo
    ../libraries/nu_packages/Demo/: usbd_cdc_vcom_echo.c slcd_show_tick.c usbd_hid_dance_mouse.c
  group nuc980_usbhostlib
    ../libraries/nuc980/UsbHostLib/src/: ehci.c mem_alloc.c ehci_iso.c usb_core.c support.c ohci.c
  group optparse
    packages/optparse-latest/: optparse.c
  group POSIX
    ../../../components/libc/posix/io/: select.c
    ../../../components/libc/posix/io/poll/: poll.c
  group ramdisk
    packages/ramdisk-latest/src/: drv_ramdisk.c
  group rt_usbd
    ../../../components/drivers/usb/usbdevice/core/: usbdevice_core.c usbdevice.c
    ../../../components/drivers/usb/usbdevice/class/: mstorage.c cdc_vcom.c
  group rt_usbh
    ../../../components/drivers/usb/usbhost/class/: udisk.c mass.c
    ../../../components/drivers/usb/usbhost/core/: hub.c usbhost.c usbhost_core.c driver.c
  group SAL
    ../../../components/net/netdev/src/: netdev_ipaddr.c netdev.c
    ../../../components/net/sal_socket/socket/: net_sockets.c net_netdb.c
    ../../../components/net/sal_socket/dfs_net/: dfs_net.c
    ../../../components/net/sal_socket/impl/: af_inet_lwip.c
    ../../../components/net/sal_socket/src/: sal_socket.c
  group UTest
    ../../../components/utilities/utest/: utest.c
