# IAR project project.ewp, settings and files
configuration Debug (V850, debug)
  General.GMemoryModel: 0
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\dl85nn1.h
  General.GHeapSize: 4096
  General.GDeviceSelect: 70F3454 V850E - uPD70F3454
  ICCV850.CCDefines: RT_USING_DLIBC; __RTTHREAD__
  ICCV850.CCDiagSuppress: Pa050
  ICCV850.CCIncludePath2: ..\..\libcpu\v850\70f34; ..\..\include; ..\..\components\libc\compilers\common\extension; ..\..\components\libc\compilers\common; ..\..\components\libc\posix\ipc; drivers; .; applications; ..\..\components\libc\posix\io\poll; ..\..\components\libc\posix\io\stdio; ..\..\components\finsh
  ICCV850.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCV850.CCOptLevel: 1
  ICCV850.CCOptStrategy: 0
  ICCV850.IccLang: 0
  AV850.ADefines: CODE_MODEL_NORMAL; DATA_MODEL_TINY
  AV850.OAStdIncludePath: $TOOLKIT_DIR$\INC\
  XLINK.XclFile: lnk70f3454.xcl
  XLINK.XlinkStackSize: 1
configuration Release (V850)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICCV850.CCDefines: NDEBUG; RT_USING_DLIBC; __RTTHREAD__
  ICCV850.CCOptLevel: 3
  XLINK.XclFile: lnk0t.xcl
  group Applications
    applications/: startup.c application.c
  group Compiler
    ../../components/libc/compilers/common/: stdlib.c time.c
    ../../components/libc/compilers/dlib/: environ.c syscall_remove.c syscalls.c syscall_read.c syscall_close.c syscall_write.c syscall_mem.c syscall_open.c syscall_lseek.c
  group CPU
    ../../libcpu/v850/70f34/: cpuport.c
  group Drivers
    drivers/: CG_timer.c CG_system_user.c board.c CG_systeminit.c cstartup.asm uart.c CG_port.c CG_timer_user.c CG_port_user.c CG_system.c
  group Finsh
    ../../components/finsh/: shell.c msh.c
  group Kernel
    ../../src/: mempool.c scheduler.c irq.c thread.c device.c mem.c object.c clock.c kservice.c idle.c timer.c components.c ipc.c
