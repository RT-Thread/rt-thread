# Keil uVision project project.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: R7FA8M1AH Renesas
  pack: Renesas.RA_DFP.5.0.0
  cpu: CPUTYPE("Cortex-M85") DSP TZ MVE(FP) FPU3(DFPU) PACBTI CLOCK(12000000) ELITTLE
  output: rtthread +hex
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3
  c define: RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND, __RTTHREAD__, RT_USING_ARMLIBC, __STDC_LIMIT_MACROS
  c misc: -Wno-license-management -Wuninitialized -Wall -Wmissing-declarations -Wpointer-arith -Waggregate-return -Wfloat-equal
  c include: ..\..\..\libcpu\arm\cortex-m85;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\libraries\HAL_Drivers;board\ports\wifi;.;..\..\..\components\libc\compilers\common\include;ra_gen;..\libraries\HAL_Drivers\drivers;ra\fsp\inc;ra_cfg\fsp_cfg\bsp;..\..\..\libcpu\arm\common;..\..\..\components\drivers\phy;..\..\..\components\libc\posix\io\eventfd;..\..\..\components\drivers\include;..\..\..\components\drivers\include;ra\fsp\inc\instances;..\..\..\components\finsh;board\ports;ra\fsp\inc\api;..\..\..\components\drivers\include;..\..\..\components\net\utest;..\..\..\components\libc\posix\io\poll;..\..\..\include;..\..\..\components\libc\posix\io\epoll;board;..\libraries\HAL_Drivers\drivers\config;ra\arm\CMSIS_5\CMSIS\Core\Include;..\..\..\components\libc\compilers\common\extension;..\..\..\components\libc\compilers\common\extension\fcntl\octal;ra_cfg\fsp_cfg;..\..\..\components\libc\posix\ipc;..\..\..\components\drivers\include;..\..\..\components\drivers\smp_call
  library: MicroLIB
  scatter file: .\script\fsp.scat
  group Applications
    src/: hal_entry.c
  group CPU
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m85/: context_gcc.S cpuport.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/pin/: dev_pin.c
    ../../../components/drivers/serial/: dev_serial_v2.c
  group Drivers
    board/: ra8_it.c
    ../libraries/HAL_Drivers/drivers/: drv_gpio.c drv_usart_v2.c
    ../libraries/HAL_Drivers/: drv_common.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group Libc
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
  group ra
    ra/fsp/src/bsp/mcu/all/: bsp_clocks.c bsp_common.c bsp_delay.c bsp_group_irq.c bsp_guard.c bsp_io.c bsp_irq.c bsp_register_protection.c bsp_rom_registers.c bsp_sbrk.c bsp_security.c
    ra/fsp/src/bsp/cmsis/Device/RENESAS/Source/: system.c startup.c
    ra/fsp/src/r_ioport/: r_ioport.c
    ra/fsp/src/r_sci_b_uart/: r_sci_b_uart.c
  group ra_gen
    ra_gen/: common_data.c hal_data.c main.c pin_data.c vector_data.c
software components: Flex Software:RA Configuration 1.0.0
