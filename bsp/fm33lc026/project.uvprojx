# Keil uVision project project.uvprojx, settings and files
target RT_Thread (ARM-ADS)
  device: FM33LC04X FMSH
  pack: Keil.FM33LC0XX_DFP.3.0.1
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x6000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: rt-thread +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: __CLK_TCK=RT_TICK_PER_SECOND, __STDC_LIMIT_MACROS, RT_USING_LIBC, RT_USING_ARMLIBC, FM33LC0XX, __RTTHREAD__, USE_HAL_DRIVER
  c include: ..\..\components\libc\posix\io\eventfd;..\..\components\drivers\smp_call;..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\components\libc\posix\io\epoll;..\..\components\finsh;applications;..\..\components\drivers\include;libraries\FM33LC0xx_FL_Driver\Inc;libraries\FM33LC0xx_FL_Driver\CMSIS\Include;.;..\..\components\drivers\include;..\..\components\libc\compilers\common\include;..\..\components\libc\posix\ipc;libraries\HAL_Drivers;..\..\components\net\utest;..\..\components\drivers\include;..\..\libcpu\arm\cortex-m0;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\libc\compilers\common\extension;board;..\..\libcpu\arm\common;..\..\components\libc\posix\io\poll;libraries\HAL_Drivers\config;..\..\components\drivers\phy;..\..\components\drivers\include;..\..\include;..\..\components\drivers\include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x6000
  group Applications
    applications/: main.c
  group CPU
    ../../libcpu/arm/common/: div0.c showmem.c
    ../../libcpu/arm/cortex-m0/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../components/drivers/core/: device.c
    ../../components/drivers/i2c/: dev_i2c_bit_ops.c dev_i2c_core.c dev_i2c_dev.c
    ../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../components/drivers/pin/: dev_pin.c
    ../../components/drivers/serial/: dev_serial.c
  group Drivers
    board/: board.c
    libraries/FM/FM33xx/Source/Templates/ARM/: startup_fm33lc0xx.s
    libraries/HAL_Drivers/: drv_common.c drv_gpio.c drv_usart.c
  group Finsh
    ../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group FM33LC0xx_FL_Driver
    libraries/FM33LC0xx_FL_Driver/CMSIS/: system_fm33lc0xx.c
    libraries/FM33LC0xx_FL_Driver/Src/: fm33lc0xx_fl_dma.c fm33lc0xx_fl_crc.c fm33lc0xx_fl_rcc.c fm33lc0xx_fl_gpio.c fm33lc0xx_fl_exti.c fm33lc0xx_fl_uart.c fm33lc0xx_fl_lpuart.c fm33lc0xx_fl_i2c.c
  group Kernel
    ../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group Libc
    ../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
