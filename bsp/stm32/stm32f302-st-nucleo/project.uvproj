# Keil uVision project project.uvproj, settings and files
target rt-thread (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: STM32F302xx, USE_HAL_DRIVER, __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND
  c include: applications;.;rt-thread\libcpu\arm\common;rt-thread\libcpu\arm\cortex-m4;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;board;board\CubeMX_Config\Inc;libraries\HAL_Drivers;libraries\HAL_Drivers\config;rt-thread\components\finsh;.;rt-thread\include;rt-thread\components\libc\compilers\common;rt-thread\components\libc\compilers\common\none-gcc;libraries\STM32F3xx_HAL\STM32F3xx_HAL_Driver\Inc;libraries\STM32F3xx_HAL\CMSIS\Device\ST\STM32F3xx\Include;libraries\STM32F3xx_HAL\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group CPU
    rt-thread/libcpu/arm/common/: backtrace.c showmem.c div0.c
    rt-thread/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
  group DeviceDrivers
    rt-thread/components/drivers/misc/: pin.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/src/: ringblk_buf.c waitqueue.c completion.c ringbuffer.c dataqueue.c pipe.c workqueue.c
  group Drivers
    board/CubeMX_Config/Src/: stm32f3xx_hal_msp.c
    board/: board.c
    libraries/STM32F3xx_HAL/CMSIS/Device/ST/STM32F3xx/Source/Templates/arm/: startup_stm32f302x8.s
    libraries/HAL_Drivers/: drv_gpio.c drv_usart.c drv_common.c
  group finsh
    rt-thread/components/finsh/: shell.c cmd.c msh.c
  group Kernel
    rt-thread/src/: irq.c components.c kservice.c device.c mempool.c mem.c scheduler.c clock.c ipc.c object.c idle.c timer.c thread.c
  group libc
    rt-thread/components/libc/compilers/common/: time.c
  group Libraries
    libraries/STM32F3xx_HAL/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal_crc.c stm32f3xx_hal_uart.c stm32f3xx_hal_usart.c stm32f3xx_hal.c stm32f3xx_hal_uart_ex.c stm32f3xx_hal_cec.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_usart_ex.c stm32f3xx_hal_cortex.c stm32f3xx_hal_exti.c stm32f3xx_hal_crc_ex.c stm32f3xx_hal_rcc.c stm32f3xx_hal_pwr.c stm32f3xx_hal_dma.c stm32f3xx_hal_sram.c
    libraries/STM32F3xx_HAL/CMSIS/Device/ST/STM32F3xx/Source/Templates/: system_stm32f3xx.c
