# Keil uVision project project.uvproj, settings and files
target RT-Thread LPC1100 (ARM-ADS)
  device: LPC1114x301 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IROM(0-0x7FFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: rtthread-lpc1100
  c flags: Optim=1
  c include: .;..\..\include;..\..\libcpu\arm\lpc1100
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group Startup
    ./: board.c startup.c application.c rtconfig.h board.h uart.c
  group Kernel
    ../../src/: clock.c device.c idle.c irq.c kservice.c mempool.c object.c scheduler.c slab.c timer.c thread.c mem.c ipc.c
  group LPC1100
    ../../libcpu/arm/lpc1100/: cpu.c fault.c interrupt.c stack.c context_rvds.S fault_rvds.S start_rvds.s
  group CMSIS
    ../../libcpu/arm/lpc1100/CMSIS/: core_cm0.c system_LPC11xx.c
