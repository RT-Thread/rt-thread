# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: HC32F4A0SITB HDSC
  pack: HDSC.HC32F4A0.1.0.8
  cpu: IROM(0x00000000,0x200000) IRAM(0x1FFE0000,0x80000)  IRAM2(0X200F0000,0x1000) CPUTYPE("Cortex-M4") FPU2 CLOCK(240000000) ESEL ELITTLE
  output: rt-thread +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: __DEBUG, __STDC_LIMIT_MACROS, RT_USING_ARMLIBC, HC32F4A0, __CLK_TCK=RT_TICK_PER_SECOND, USE_DDL_DRIVER, RT_USING_LIBC, __RTTHREAD__
  c include: ..\..\..\components\drivers\phy;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\libcpu\arm\common;board\config\usb_config;..\..\..\components\drivers\include;..\..\..\components\drivers\smp_call;..\..\..\components\libc\posix\io\eventfd;board\config;..\..\..\components\libc\posix\io\epoll;board\ports;applications;..\..\..\components\libc\compilers\common\extension;..\libraries\hc32f4a0_ddl\cmsis\Include;..\libraries\hc32f4a0_ddl\hc32_ll_driver\inc;..\platform\tca9539;..\..\..\include;..\..\..\components\libc\posix\io\poll;..\..\..\components\libc\posix\ipc;..\..\..\libcpu\arm\cortex-m4;..\..\..\components\drivers\include;..\..\..\components\finsh;..\..\..\components\drivers\include;..\libraries\hc32f4a0_ddl\cmsis\Device\HDSC\hc32f4xx\Include;..\..\..\components\libc\compilers\common\extension\fcntl\octal;.;..\..\..\components\libc\compilers\common\include;..\..\..\components\drivers\include;board;..\libraries\hc32_drivers;..\tests
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x3000000 size 0x1800
  memory RVCT9: RAM 0x1ffe0000 size 0x80000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: xtal32_fcm.c main.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/i2c/: dev_i2c_bit_ops.c dev_i2c_core.c dev_i2c_dev.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/pin/: dev_pin.c
    ../../../components/drivers/serial/: dev_serial.c
  group Drivers
    board/: board.c board_config.c
    ../libraries/hc32f4a0_ddl/cmsis/Device/HDSC/hc32f4xx/Source/ARM/: startup_hc32f4a0.s
    ../libraries/hc32_drivers/: drv_common.c drv_gpio.c drv_i2c.c drv_irq.c drv_soft_i2c.c drv_usart.c
  group Finsh
    ../../../components/finsh/: cmd.c shell.c msh_parse.c msh.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    ../../../src/klibc/: rt_vsnprintf_tiny.c kerrno.c kstring.c kstdio.c rt_vsscanf.c
  group libcpu
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group Libraries
    ../libraries/hc32f4a0_ddl/hc32_ll_driver/src/: hc32_ll_tmr0.c hc32_ll.c hc32_ll_pwc.c hc32_ll_utility.c hc32_ll_i2c.c hc32_ll_dma.c hc32_ll_rmu.c hc32_ll_icg.c hc32f4a0_ll_interrupts_share.c hc32_ll_usart.c hc32_ll_gpio.c hc32_ll_efm.c hc32_ll_fcg.c hc32_ll_sram.c hc32_ll_clk.c hc32_ll_interrupts.c hc32_ll_aos.c
    ../libraries/hc32f4a0_ddl/cmsis/Device/HDSC/hc32f4xx/Source/: system_hc32f4a0.c
  group Platform
    ../platform/tca9539/: tca9539.c
  group Tests
    ../tests/: test_i2c.c test_uart_v1.c test_gpio.c test_soft_i2c.c
