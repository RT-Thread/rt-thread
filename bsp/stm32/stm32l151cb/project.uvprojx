# Keil uVision project project.uvprojx, settings and files
target rt-thread (ARM-ADS)
  device: STM32L151CBxxA STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00008000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rt-thread +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32L151xB
  c include: .;../../../../../../../mnt/hgfs/code/SDK/rt-thread/include;applications;.;board;board/CubeMX_Config/Inc;board/ports;../libraries/HAL_Drivers;../libraries/HAL_Drivers/config;../../../../../../../mnt/hgfs/code/SDK/rt-thread/libcpu/arm/common;../../../../../../../mnt/hgfs/code/SDK/rt-thread/libcpu/arm/cortex-m3;../../../../../../../mnt/hgfs/code/SDK/rt-thread/components/drivers/include;../../../../../../../mnt/hgfs/code/SDK/rt-thread/components/drivers/include;../../../../../../../mnt/hgfs/code/SDK/rt-thread/components/drivers/include;../../../../../../../mnt/hgfs/code/SDK/rt-thread/components/finsh;../libraries/STM32L1xx_HAL/CMSIS/Device/ST/STM32L1xx/Include;../libraries/STM32L1xx_HAL/STM32L1xx_HAL_Driver/Inc;../libraries/STM32L1xx_HAL/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --keep *.o(.rti_fn.*)   --keep *.o(FSymTab)
  group Kernel
    ../../../../../../../mnt/hgfs/code/SDK/rt-thread/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group Applications
    applications/: main.c
  group Drivers
    board/: board.c
    board/CubeMX_Config/Src/: stm32l1xx_hal_msp.c
    ../libraries/STM32L1xx_HAL/CMSIS/Device/ST/STM32L1xx/Source/Templates/arm/: startup_stm32l151xba.s
    ../libraries/HAL_Drivers/: drv_gpio.c drv_usart.c drv_common.c
  group cpu
    ../../../../../../../mnt/hgfs/code/SDK/rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../../../../../../mnt/hgfs/code/SDK/rt-thread/libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
  group DeviceDrivers
    ../../../../../../../mnt/hgfs/code/SDK/rt-thread/components/drivers/misc/: pin.c
    ../../../../../../../mnt/hgfs/code/SDK/rt-thread/components/drivers/serial/: serial.c
    ../../../../../../../mnt/hgfs/code/SDK/rt-thread/components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
  group finsh
    ../../../../../../../mnt/hgfs/code/SDK/rt-thread/components/finsh/: shell.c symbol.c cmd.c msh.c msh_cmd.c msh_file.c
  group STM32_HAL
    ../libraries/STM32L1xx_HAL/CMSIS/Device/ST/STM32L1xx/Source/Templates/: system_stm32l1xx.c
    ../libraries/STM32L1xx_HAL/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal.c stm32l1xx_hal_dma.c stm32l1xx_hal_cortex.c stm32l1xx_hal_crc.c stm32l1xx_hal_pwr.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_sram.c stm32l1xx_hal_gpio.c stm32l1xx_hal_uart.c stm32l1xx_hal_usart.c
