# Keil uVision project project.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: NUC472HI8AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: template +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: applications;.;drivers;Libraries\CMSIS\Include;Libraries\Device\Nuvoton\NUC472_442\Include;Libraries\StdDriver\inc;..\..\include;..\..\libcpu\arm\cortex-m4;..\..\libcpu\arm\common;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\finsh
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --keep *.o(.rti_fn.*)   --keep *.o(FSymTab)
  group Applications
    applications/: application.c
  group Drivers
    drivers/: board.c usart.c
  group CMSIS
    Libraries/Device/Nuvoton/NUC472_442/Source/: system_NUC472_442.c
    Libraries/Device/Nuvoton/NUC472_442/Source/ARM/: startup_NUC472_442.s
  group NUC472_StdPeriph
    Libraries/StdDriver/src/: acmp.c adc.c can.c cap.c clk.c crc.c crypto.c eadc.c ebi.c emac.c epwm.c fmc.c gpio.c i2c.c i2s.c pdma.c ps2.c pwm.c rtc.c sc.c scuart.c sd.c spi.c sys.c timer_.c uart.c usbd.c wdt.c wwdt.c
  group Kernel
    ../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group CORTEX-M4
    ../../libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
  group DeviceDrivers
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/src/: completion.c dataqueue.c pipe.c ringbuffer.c waitqueue.c workqueue.c
  group finsh
    ../../components/finsh/: shell.c symbol.c cmd.c msh.c msh_cmd.c msh_file.c
