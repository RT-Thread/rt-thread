# IAR project template.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M031AE series Nuvoton M031AE series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: ARM_MATH_CM0
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: rtthread.bin
  ILINK.IlinkOutputFile: Template.out
  ILINK.IlinkIcfFile: linking_scripts\m031_flash.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
