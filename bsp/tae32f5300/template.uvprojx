# Keil uVision project template.uvprojx, settings and files
target rtthread (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: TAE32F5300 Tai-Action
  pack: Tai-Action.TAE32F53xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x4000) IRAM2(0x20004000,0x1000) IRAM3(0x20005000,0x1000) IROM(0x08000000,0x12c00) IROM2(0x18000000,0x4000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rtthread +hex
  AfterMake: .\AfterBuildHandler.bat $J #L
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: USE_STDPERIPH_DRIVER
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x12c00
  memory RVCT5: ROM 0x18000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x4000
  memory RVCT10: RAM 0x20004000 size 0x1000
  scatter file: .\board\linker_scripts\tae32f53xx_ac5_flash.sct
  link misc: --diag_suppress=L6314W
