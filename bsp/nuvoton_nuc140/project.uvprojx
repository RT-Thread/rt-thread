# Keil uVision project project.uvprojx, settings and files
target NUC140 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: NUC140RE3CN Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.5
  cpu: IRAM(0x20000000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: NUC140 +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\bin\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\bin\@L.txt"
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: INIT_SYSCLK_AT_BOOTING
  c include: .;..\..\include;applications;.;drivers;Libraries\StdDriver\inc;Libraries\CMSIS\Nuvoton\M051Series\Include;Libraries\CMSIS\Include;..\..\libcpu\arm\common;..\..\libcpu\arm\cortex-m0;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\finsh;..\..\components\libc\compilers\common
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\nuvoton_nuc140.sct
  group Kernel
    ../../src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c object.c scheduler.c signal.c thread.c timer.c
  group Applications
    applications/: main.c
  group Drivers
    drivers/: board.c led.c usart.c
  group NUC1X0_StdPeriph
    ./Libraries/StdDriver/src/: acmp.c adc.c clk.c crc.c fmc.c gpio.c i2c.c i2s.c pdma.c ps2.c pwm.c rtc.c sc.c spi.c sys.c timer.c uart.c usbd.c wdt.c wwdt.c
    ./Libraries/Device/Nuvoton/NUC100Series/Source/: system_NUC100Series.c
    ./Libraries/Device/Nuvoton/NUC100Series/Source/ARM/: startup_NUC100Series.s
  group cpu
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../libcpu/arm/cortex-m0/: cpuport.c context_rvds.S
  group DeviceDrivers
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
  group finsh
    ../../components/finsh/: shell.c cmd.c msh.c
