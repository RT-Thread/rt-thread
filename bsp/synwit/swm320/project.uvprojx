# Keil uVision project project.uvprojx, settings and files
target rtthread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: SWM320xE Synwit
  pack: Synwit.SWM32_DFP.1.11.2
  cpu: IRAM(0x20000000,0x20000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: RT_USING_LIBC, RT_USING_ARMLIBC, __STDC_LIMIT_MACROS, __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND
  c include: ..\..\..\components\libc\compilers\common\extension\fcntl\octal;libraries\CMSIS\CoreSupport;..\..\..\include;drivers;..\..\..\components\libc\compilers\common\include;libraries\SWM320_StdPeriph_Driver;..\..\..\components\libc\compilers\common\extension;..\..\..\components\drivers\include;..\..\..\components\libc\posix\io\stdio;libraries\CMSIS\DeviceSupport;applications;..\..\..\libcpu\arm\cortex-m4;..\..\..\components\drivers\include;..\..\..\components\libc\posix\ipc;..\..\..\components\finsh;..\..\..\libcpu\arm\common;..\..\..\components\libc\posix\io\poll;..\..\..\components\drivers\include;.
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\drivers\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdio.c cstdlib.c cstring.c ctime.c cwchar.c
  group CPU
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../../components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/serial/: serial.c
  group Drivers
    drivers/: drv_gpio.c drv_uart.c board.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler_up.c thread.c timer.c
  group Libraries
    libraries/SWM320_StdPeriph_Driver/: SWM320_gpio.c SWM320_wdt.c SWM320_lcd.c SWM320_flash.c SWM320_spi.c SWM320_adc.c SWM320_sdram.c SWM320_norflash.c SWM320_pwm.c SWM320_sdio.c SWM320_sram.c SWM320_uart.c SWM320_i2c.c SWM320_timr.c SWM320_exti.c SWM320_port.c SWM320_dma.c SWM320_crc.c SWM320_rtc.c SWM320_can.c
    libraries/CMSIS/DeviceSupport/: system_SWM320.c
    libraries/CMSIS/DeviceSupport/startup/arm/: startup_SWM320.s
