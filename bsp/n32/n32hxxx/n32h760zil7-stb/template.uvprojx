# Keil uVision project template.uvprojx, settings and files
target rt-thread (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: N32H760xIx7 Nationstech
  pack: Nationstech.N32H7xx_DFP.1.2.0
  cpu: IRAM(0x24000000,0x20000) IROM(0x15000000,0x1E0000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rt-thread +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1
  library: MicroLIB
  memory RVCT4: ROM 0x15000000 size 0x1e0000
  memory RVCT9: RAM 0x24000000 size 0x20000
  scatter file: .\board\linker_scripts\link.sct
  link misc: --entry Reset_Handler
