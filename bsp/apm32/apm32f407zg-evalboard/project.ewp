# IAR project project.ewp, settings and files
configuration rt-thread (ARM, debug)
  General.OGChipSelectEditMenu: APM32F407ZG Geehy APM32F407ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: APM32F40X; __RTTHREAD__; CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; USE_STDPERIPH_DRIVER; __RT_IPC_SOURCE__; __RT_KERNEL_SOURCE__
  ICCARM.CCIncludePath2: applications; ..\..\..\libcpu\arm\common; ..\..\..\libcpu\arm\cortex-m4; ..\..\..\components\drivers\include; ..\..\..\components\drivers\phy; ..\..\..\components\drivers\smp_call; board; board\ports; ..\libraries\Drivers; ..\libraries\Drivers\config; ..\..\..\components\finsh; .; ..\..\..\include; ..\..\..\components\libc\compilers\common\include; ..\..\..\components\libc\compilers\common\extension; ..\..\..\components\libc\compilers\common\extension\fcntl\octal; ..\..\..\components\libc\posix\io\epoll; ..\..\..\components\libc\posix\io\eventfd; ..\..\..\components\libc\posix\io\poll; ..\..\..\components\libc\posix\ipc; ..\libraries\APM32F4xx_Library\Device\Geehy\APM32F4xx\Include; ..\libraries\APM32F4xx_Library\APM32F4xx_StdPeriphDriver\inc; ..\libraries\APM32F4xx_Library\CMSIS\Include; ..\libraries\APM32F4xx_Library\APM32F4xx_ETH_Driver\inc; ..\..\..\components\net\utest
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../rtthread.bin
  ILINK.IlinkOutputFile: template.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; APM32F40X; __RTTHREAD__; CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; USE_STDPERIPH_DRIVER; __RT_IPC_SOURCE__; __RT_KERNEL_SOURCE__
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: main.c
  group CPU
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m4/: context_iar.S cpuport.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/pin/: dev_pin.c
    ../../../components/drivers/serial/: dev_serial.c
  group Drivers
    board/: board.c
    ../libraries/APM32F4xx_Library/Device/Geehy/APM32F4xx/Source/iar/: startup_apm32f40x.s
    ../libraries/Drivers/: drv_common.c drv_gpio.c drv_usart.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group Libc
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
    ../../../src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
  group Libraries
    ../libraries/APM32F4xx_Library/Device/Geehy/APM32F4xx/Source/: system_apm32f4xx.c
    ../libraries/APM32F4xx_Library/APM32F4xx_StdPeriphDriver/src/: apm32f4xx_gpio.c apm32f4xx_syscfg.c apm32f4xx_misc.c apm32f4xx_rcm.c apm32f4xx_usart.c apm32f4xx_eint.c apm32f4xx_dma.c
