# Keil uVision project project.uvprojx, settings and files
target rtthread-frdm-mcxc444 (6190000::V6.19::ARMCLANG)
  device: MCXC444VLH NXP
  pack: NXP.MCXC444_DFP.17.0.0
  cpu: IRAM(0x1fffe000,0x8000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: rtthread
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=3
  c define: __CLK_TCK=RT_TICK_PER_SECOND, __STDC_LIMIT_MACROS, CPU_MCXC444VLH, DEBUG, __RTTHREAD__, RT_USING_LIBC, RT_USING_ARMLIBC
  c misc: --target=arm-arm-none-eabi
  c include: ..\Libraries\CMSIS\Core\Include;board;..\..\..\..\..\libcpu\arm\common;..\..\..\..\..\components\finsh;..\Libraries\drivers\config;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\libc\posix\ipc;..\..\..\..\..\components\libc\compilers\common\include;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\libc\posix\io\eventfd;.;..\Libraries\drivers;..\..\..\..\..\components\libc\compilers\common\extension;..\..\..\..\..\components\drivers\include;board\MCUX_Config\board;..\..\..\..\..\include;..\..\..\..\..\libcpu\arm\cortex-m0;..\..\..\..\..\components\libc\posix\io\poll;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\drivers\include;..\Libraries\MCXC444\MCXC444\drivers;..\..\..\..\..\components\libc\posix\io\epoll;applications;..\Libraries\MCXC444\MCXC444;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\drivers\spi;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\libc\compilers\common\extension\fcntl\octal
  asm misc: -x assembler-with-cpp
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x8000
  scatter file: .\board\linker_scripts\MCXC444_flash.scf
  group Applications
    applications/: main.c
  group Compiler
    ../../../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../../../components/drivers/core/: device.c
    ../../../../../components/drivers/hwtimer/: hwtimer.c
    ../../../../../components/drivers/i2c/: dev_i2c_bit_ops.c dev_i2c_core.c dev_i2c_dev.c
    ../../../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../../components/drivers/misc/: rt_drv_pwm.c
    ../../../../../components/drivers/pin/: dev_pin.c
    ../../../../../components/drivers/rtc/: dev_rtc.c
    ../../../../../components/drivers/serial/: serial.c
    ../../../../../components/drivers/spi/: spi_core.c spi_dev.c
  group Drivers
    board/MCUX_Config/board/: clock_config.c pin_mux.c
    board/: board.c
    ../Libraries/drivers/: drv_pin.c drv_uart.c
  group Finsh
    ../../../../../components/finsh/: msh_parse.c shell.c cmd.c msh.c
  group Kernel
    ../../../../../src/: clock.c components.c cpu_up.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
    ../../../../../src/klibc/: kstdio.c kstring.c
  group libcpu
    ../../../../../libcpu/arm/common/: div0.c showmem.c
    ../../../../../libcpu/arm/cortex-m0/: context_rvds.S cpuport.c
  group Libraries
    ../Libraries/MCXC444/MCXC444/drivers/: fsl_dac.c fsl_uart_dma.c fsl_sai_dma.c fsl_lpuart.c fsl_slcd.c fsl_pit.c fsl_lpuart_dma.c fsl_cop.c fsl_cmp.c fsl_spi.c fsl_i2c_dma.c fsl_tpm.c fsl_gpio.c fsl_common.c fsl_ftfx_controller.c fsl_ftfx_flexnvm.c fsl_common_arm.c fsl_smc.c fsl_dma.c fsl_rtc.c fsl_sim.c fsl_sai.c fsl_pmc.c fsl_uart.c fsl_adc16.c fsl_i2c.c fsl_clock.c
    ../Libraries/MCXC444/MCXC444/arm/: startup_MCXC444.s
    ../Libraries/MCXC444/MCXC444/: system_MCXC444.c
