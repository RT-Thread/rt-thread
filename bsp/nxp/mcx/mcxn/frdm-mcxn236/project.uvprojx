# Keil uVision project project.uvprojx, settings and files
target rtthread-frdm-mcxn236 (6190000::V6.19::ARMCLANG)
  device: MCXN236VDF NXP
  pack: NXP.MCXN236_DFP.19.0.0
  cpu: IRAM(0x20000000,0x038000) IRAM2(0x04000000,0x018000) IROM(0x03000000,0x040000) IROM2(0x13000000,0x040000) XRAM(0x14000000,0x018000) XRAM2(0x30000000,0x038000) XROM(0x00000000,0x080000) XROM2(0x00080000,0x080000) XROM3(0x10000000,0x080000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: rtthread
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=3
  c define: __CLK_TCK=RT_TICK_PER_SECOND, CPU_MCXN236VDF, DEBUG, RT_USING_ARMLIBC, RT_USING_LIBC, __RTTHREAD__, __STDC_LIMIT_MACROS
  c misc: --target=arm-arm-none-eabi
  c include: ..\..\..\..\..\components\utilities\ulog;..\..\..\..\..\components\finsh;.;..\..\..\..\..\components\libc\posix\io\eventfd;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\drivers\include;..\..\..\..\..\include;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\libc\posix\ipc;..\..\..\..\..\components\libc\posix\io\epoll;..\..\..\..\..\components\drivers\include;applications;board\MCUX_Config\board;..\libraries\MCXN236\MCXN236;..\..\..\..\..\components\libc\compilers\common\include;..\..\..\..\..\components\libc\posix\io\poll;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\drivers\include;..\..\..\..\..\components\drivers\include;..\libraries\MCXN236\MCXN236\drivers;..\..\..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\..\..\components\libc\compilers\common\extension;..\libraries\drivers;..\libraries\CMSIS\Core\Include;..\..\..\..\..\libcpu\arm\cortex-m33;board;..\..\..\..\..\libcpu\arm\common;..\libraries\drivers\config
  asm misc: -x assembler-with-cpp
  memory RVCT1: ROM 0x0 size 0x80000
  memory RVCT2: ROM 0x80000 size 0x80000
  memory RVCT3: ROM 0x10000000 size 0x80000
  memory RVCT4: ROM 0x3000000 size 0x40000
  memory RVCT5: ROM 0x13000000 size 0x40000
  memory RVCT6: RAM 0x14000000 size 0x18000
  memory RVCT7: RAM 0x30000000 size 0x38000
  memory RVCT9: RAM 0x20000000 size 0x38000
  memory RVCT10: RAM 0x4000000 size 0x18000
  scatter file: .\board\linker_scripts\MCXN236_flash.scf
  group Applications
    applications/: main.c
  group Compiler
    ../../../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../../../components/drivers/can/: can.c
    ../../../../../components/drivers/core/: device.c
    ../../../../../components/drivers/clock_time/: clock_timer.c
    ../../../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../../components/drivers/pin/: pin.c
    ../../../../../components/drivers/serial/: serial.c
    ../../../../../components/drivers/watchdog/: watchdog.c
  group Drivers
    board/MCUX_Config/board/: clock_config.c pin_mux.c
    board/: board.c
    ../libraries/drivers/: drv_can.c drv_pin.c drv_uart.c drv_wdt.c
  group Finsh
    ../../../../../components/finsh/: shell.c cmd.c msh_parse.c msh.c
  group Kernel
    ../../../../../src/: clock.c components.c cpu_up.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
    ../../../../../src/klibc/: kstdio.c kstring.c
  group libcpu
    ../../../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../../../libcpu/arm/cortex-m33/: context_rvds.S cpuport.c syscall_rvds.S trustzone.c
  group Libraries
    ../libraries/MCXN236/MCXN236/drivers/: fsl_flexio_spi_edma.c fsl_mrt.c fsl_cdog.c fsl_i3c_edma.c fsl_flexio_uart_edma.c fsl_edma.c fsl_common_arm.c fsl_freqme.c fsl_lpflexcomm.c fsl_lptmr.c fsl_ctimer.c fsl_i3c.c fsl_irtc.c fsl_lpi2c_edma.c fsl_flexio_i2c_master.c fsl_ewm.c fsl_edma_soc.c fsl_flexcan.c fsl_evtg.c fsl_flexio_mculcd_edma.c fsl_clock.c fsl_cache_lpcac.c fsl_eim.c fsl_erm.c fsl_flexio_uart.c fsl_wwdt.c fsl_lpadc.c fsl_vref.c fsl_lpspi_edma.c fsl_flexcan_edma.c fsl_lpi2c.c fsl_crc.c fsl_lpuart.c fsl_flexio.c fsl_flexio_spi.c fsl_spc.c fsl_common.c fsl_reset.c fsl_gpio.c fsl_lpspi.c fsl_flexio_mculcd.c fsl_cmc.c
    ../libraries/MCXN236/MCXN236/: system_MCXN236.c
    ../libraries/MCXN236/MCXN236/arm/: startup_MCXN236.S
  group Utilities
    ../../../../../components/utilities/ulog/backend/: console_be.c
    ../../../../../components/utilities/ulog/: ulog.c
