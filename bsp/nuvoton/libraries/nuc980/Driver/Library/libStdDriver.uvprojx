# Keil uVision project libStdDriver.uvprojx, settings and files
target libstddriver-nuc980 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: AT91SAM9260 Atmel
  cpu: IRAM(0x200000-0x200FFF) IRAM2(0x300000-0x300FFF) IROM(0x100000-0x107FFF) CLOCK(18432000) CPUTYPE(ARM926EJ-S)
  output: libstddriver_keil +hex (library)
  AfterMake: xcopy /y ".\build\keil5\@L.lib" "."
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --c99
  c include: ..\Include;..\Library
  memory RVCT1: ROM 0x20000000 size 0x800000
  memory RVCT4: ROM 0x100000 size 0x8000
  memory RVCT6: RAM 0x20800000 size 0x1800000
  memory RVCT9: RAM 0x200000 size 0x1000
  memory RVCT10: RAM 0x300000 size 0x1000
  group src
    ../Source/: nu_can.c nu_cap.c nu_crypto.c nu_ebi.c nu_emac.c nu_etimer.c nu_gpio.c nu_i2c.c nu_i2s.c nu_pdma.c nu_qspi.c nu_rtc.c nu_scuart.c nu_sdh.c nu_spi.c nu_sys.c nu_uart.c nu_usbd.c nu_wdt.c nu_wwdt.c
