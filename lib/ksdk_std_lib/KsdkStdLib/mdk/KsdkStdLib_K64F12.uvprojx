# Keil uVision project KsdkStdLib_K64F12.uvprojx, settings and files
target KsdkStdLib_K64F12 Debug (ARM-ADS)
  device: MK64FN1M0xxx12 Freescale
  cpu: CPUTYPE("Cortex-M4.fp")
  output: libksdk_std.lib (library)
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: DEBUG, CPU_MK64FN1M0VMD12
  c misc: --diag_suppress=66 
-J..\..\..\..\utilities\stdlib\include,..\..\..\..\utilities\stdlib\stdio,..\..\..\..\platform\utilities\src  -J#J
  c include: ../../../../utilities/stdlib/include;../../../../utilities/stdlib/stdio;../../../../platform/utilities/src;../../../../include
  asm define: DEBUG
  asm misc: --cpreproc_opts '-DDEBUG'
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  group std-include
    ../../../../utilities/stdlib/include/: strings.h std_prv.h stdio.h
  group std-stdio
    ../../../../utilities/stdlib/stdio/: buf_prv.c buf_prv.h err.c fclose.c fflush.c fopen.c fread.c fwrite.c get.c pos.c print.c put.c scan.c stdio.c std_prv.c
    ../../../../platform/utilities/src/: print_scan.c print_scan.h
  group std-strings
    ../../../../utilities/stdlib/strings/: strings.c
target KsdkStdLib_K64F12 Release (ARM-ADS)
  device: MK64FN1M0xxx12 Freescale
  cpu: CPUTYPE("Cortex-M4.fp")
  output: libksdk_std.lib (library)
  c flags: Optim=4 OneElfS=1
  c define: NDEBUG, CPU_MK64FN1M0VMD12
  c misc: as above
  c include: as above
  asm define: NDEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
