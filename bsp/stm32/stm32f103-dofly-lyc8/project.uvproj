# Keil uVision project project.uvproj, settings and files
target rt-thread (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: STM32F103xB, USE_HAL_DRIVER, __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND
  c include: applications;.;..\..\..\libcpu\arm\common;..\..\..\libcpu\arm\cortex-m3;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;board;board\CubeMX_Config\Inc;..\libraries\HAL_Drivers;..\libraries\HAL_Drivers\config;..\..\..\components\finsh;.;..\..\..\include;..\..\..\components\libc\compilers\common;..\..\..\components\libc\compilers\common\nogcc;..\libraries\STM32F1xx_HAL\CMSIS\Device\ST\STM32F1xx\Include;..\libraries\STM32F1xx_HAL\STM32F1xx_HAL_Driver\Inc;..\libraries\STM32F1xx_HAL\CMSIS\Include;..\..\..\examples\utest\testcases\kernel
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group CPU
    ../../../libcpu/arm/common/: showmem.c backtrace.c div0.c
    ../../../libcpu/arm/cortex-m3/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/src/: workqueue.c ringbuffer.c dataqueue.c waitqueue.c ringblk_buf.c pipe.c completion.c
  group Drivers
    ../libraries/STM32F1xx_HAL/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xb.s
    board/CubeMX_Config/Src/: stm32f1xx_hal_msp.c
    board/: board.c
    ../libraries/HAL_Drivers/: drv_gpio.c drv_usart.c drv_common.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c cmd.c
  group Kernel
    ../../../src/: clock.c mem.c timer.c ipc.c components.c object.c irq.c kservice.c device.c mempool.c idle.c scheduler.c thread.c
  group libc
    ../../../components/libc/compilers/common/: time.c
  group Libraries
    ../libraries/STM32F1xx_HAL/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_pwr.c stm32f1xx_hal_dma.c stm32f1xx_hal_crc.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_cec.c stm32f1xx_hal_usart.c stm32f1xx_hal_gpio.c
    ../libraries/STM32F1xx_HAL/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
