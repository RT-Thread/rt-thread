# Keil uVision project template.uvproj, settings and files
target rtthread (ARM-ADS)
  device: Nuvoton_ARM9_Series Nuvoton
  output: rtthread
  c flags: Optim=3 wLevel=2
  c define: RT_USING_INTERRUPT_INFO
  c misc: --c99
  scatter file: .\linking_scripts\n9h30.sct
