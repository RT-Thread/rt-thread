# IAR project project.ewp, settings and files
configuration rtthread (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1176xxxA_M7 NXP MIMXRT1176xxxA_M7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 0
  ICCARM.CCDefines: RT_USING_DLIBC; CPU_MIMXRT1176DVMAA_cm7; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=1; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; XIP_EXTERNAL_FLASH=1; ARM_MATH_CM7; USE_SDRAM; __RTTHREAD__
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ..\..\..\components\finsh; ..\..\..\components\drivers\include; ..\libraries\MIMXRT1170\MIMXRT1176; ..\..\..\components\libc\compilers\common; xip; ..\..\..\components\libc\posix\ipc; ..\..\..\components\libc\posix\io\stdio; ..\libraries\drivers; ..\libraries\MIMXRT1170\CMSIS\Core\Include; ..\..\..\examples\utest\testcases\kernel; .; ..\libraries\MIMXRT1170\MIMXRT1176\drivers; board; board\MCUX_Config; board\ports; ..\libraries\drivers\config; applications; ..\..\..\components\libc\posix\io\poll; ..\libraries\peripherals; ..\..\..\include; ..\..\..\libcpu\arm\common; ..\..\..\libcpu\arm\cortex-m7; ..\..\..\components\net\netdev\include; ..\..\..\components\libc\compilers\common\extension
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: template.srec
  ILINK.IlinkOutputFile: rtthread.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Applications
    applications/: main.c mnt.c
  group Compiler
    ../../../components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
    ../../../components/libc/compilers/common/: stdlib.c time.c
  group CPU
    ../../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m7/: context_iar.S cpu_cache.c cpuport.c
  group DeviceDrivers
    ../../../components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/cputime/: cputime.c
    ../../../components/drivers/phy/: phy.c
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/serial/: serial.c
  group Drivers
    board/: board.c dcd.c
    board/MCUX_Config/: clock_config.c pin_mux.c
    ../libraries/drivers/: drv_uart.c
  group Finsh
    ../../../components/finsh/: msh.c shell.c
  group Kernel
    ../../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler.c thread.c timer.c
  group Libraries
    ../libraries/MIMXRT1170/MIMXRT1176/drivers/: fsl_anatop_ai.c fsl_clock.c fsl_common.c fsl_common_arm.c fsl_dcdc.c fsl_lpuart.c fsl_pmu.c
    ../libraries/MIMXRT1170/MIMXRT1176/drivers/cm7/: fsl_cache.c
    ../libraries/MIMXRT1170/MIMXRT1176/iar/: startup_MIMXRT1176_cm7.s
    ../libraries/MIMXRT1170/MIMXRT1176/: system_MIMXRT1176_cm7.c
  group SAL
    ../../../components/net/netdev/src/: netdev.c netdev_ipaddr.c
  group xip
    xip/: evkmimxrt1170_flexspi_nor_config.c fsl_flexspi_nor_boot.c
