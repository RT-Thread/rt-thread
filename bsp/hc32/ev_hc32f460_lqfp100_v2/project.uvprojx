# Keil uVision project project.uvprojx, settings and files
target rt-thread (6220000::V6.22::ARMCLANG)
  device: HC32F460PETB HDSC
  pack: HDSC.HC32F460.1.0.11
  cpu: IROM1(0x00000000,0x80000) IROM2(0x03000C00,0x3FC) IRAM1(0x1FFF8000,0x2F000)  IRAM2(0x200F0000,0x1000) CPUTYPE("Cortex-M4") FPU2 CLOCK(8000000) ESEL ELITTLE
  output: rt-thread +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: RT_USING_LIBC, RT_USING_ARMLIBC, __STDC_LIMIT_MACROS, __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND, HC32F460, USE_DDL_DRIVER, __DEBUG
  c include: ..\..\..\components\drivers\include;..\..\..\components\drivers\phy;applications;..\..\..\components\drivers\include;..\..\..\components\libc\compilers\common\include;board\config;..\..\..\components\libc\posix\io\poll;..\tests;board;..\..\..\components\libc\posix\io\eventfd;..\..\..\libcpu\arm\cortex-m4;board\ports;..\..\..\components\libc\posix\ipc;..\..\..\components\libc\compilers\common\extension;packages\hc32-f4-series-latest\hc32f460\inc;board\config\usb_config;packages\hc32-f4-cmsis-latest\Device\HDSC\hc32f460\Include;..\..\..\include;..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\components\finsh;..\..\..\libcpu\arm\common;..\..\..\components\drivers\smp_call;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\libraries\hc32_drivers;.;..\..\..\components\drivers\include;packages\hc32-f4-cmsis-latest\Include;..\..\..\components\libc\posix\io\epoll;..\..\..\components\drivers\include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x3000c00 size 0x3c0
  memory RVCT9: RAM 0x1fff8000 size 0x2f000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: xtal32_fcm.c main.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/i2c/: dev_i2c_bit_ops.c dev_i2c_core.c dev_i2c_dev.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/pin/: dev_pin.c
    ../../../components/drivers/serial/: dev_serial.c
  group Drivers
    board/: board.c board_config.c
    ../libraries/hc32_drivers/: drv_common.c drv_gpio.c drv_i2c.c drv_irq.c drv_soft_i2c.c drv_usart.c
  group Finsh
    ../../../components/finsh/: msh_parse.c shell.c msh.c cmd.c
  group HC32F460-LL
    packages/hc32-f4-series-latest/hc32f460/src/: hc32f460_ll_interrupts_share.c hc32_ll_utility.c hc32_ll_aos.c hc32_ll_event_port.c hc32_ll_fcg.c hc32_ll_tmr0.c hc32_ll_clk.c hc32_ll_emb.c hc32_ll_cmp.c hc32_ll_keyscan.c hc32_ll_sram.c hc32_ll_mpu.c hc32_ll_dcu.c hc32_ll_dbgc.c hc32_ll_ots.c hc32_ll_i2c.c hc32_ll_rmu.c hc32_ll_i2s.c hc32_ll_interrupts.c hc32_ll.c hc32_ll_pwc.c hc32_ll_efm.c hc32_ll_gpio.c hc32_ll_dma.c hc32_ll_icg.c hc32_ll_usart.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    ../../../src/klibc/: rt_vsnprintf_tiny.c kstring.c kerrno.c rt_vsscanf.c kstdio.c
  group libcpu
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group Libraries
    packages/hc32-f4-cmsis-latest/Device/HDSC/hc32f460/Source/: system_hc32f460.c
    packages/hc32-f4-cmsis-latest/Device/HDSC/hc32f460/Source/ARM/: startup_hc32f460.s
  group Tests
    ../tests/: test_soft_i2c.c test_uart_v1.c test_i2c.c test_gpio.c
