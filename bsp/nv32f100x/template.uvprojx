# Keil uVision project template.uvprojx, settings and files
target nv32f100x (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: NV32F100FS16E Navota MCU
  pack: Keil.NV32F100_DFP.1.0
  cpu: IRAM(0x1FFFF800,0x2000) IROM(0x00000000,0x20000) IROM2(0x00400000,0x1400) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: nv32f100x
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x1400
  memory RVCT9: RAM 0x1ffff800 size 0x2000
  link misc: --keep *.o(.rti_fn.*)   --keep *.o(FSymTab)
