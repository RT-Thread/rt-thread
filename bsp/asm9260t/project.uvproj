# Keil uVision project project.uvproj, settings and files
target rtthread (ARM-ADS)
  device: AT91SAM9260 Atmel
  cpu: IRAM(0x200000-0x200FFF) IRAM2(0x300000-0x300FFF) IROM(0x100000-0x107FFF) CLOCK(18432000) CPUTYPE(ARM926EJ-S)
  output: template
  c flags: Optim=1 wLevel=2
  c define: __RTTHREAD__, RT_USING_LIBC, __STDC_LIMIT_MACROS, RT_USING_ARMLIBC, __CLK_TCK=RT_TICK_PER_SECOND
  c include: ..\..\components\libc\posix\ipc;..\..\include;.;..\..\libcpu\arm\arm926;..\..\components\libc\compilers\common\include;..\..\components\libc\posix\io\epoll;..\..\components\libc\posix\io\poll;..\..\components\libc\posix\io\eventfd;..\..\components\net\utest;drivers;..\..\components\drivers\phy;..\..\components\drivers\include;..\..\components\drivers\include;applications;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\components\drivers\smp_call;..\..\components\drivers\include;..\..\components\finsh;platform;..\..\libcpu\arm\common;..\..\components\libc\compilers\common\extension
  asm include: .\platform
  memory RVCT1: ROM 0x20000000 size 0x800000
  memory RVCT4: ROM 0x100000 size 0x8000
  memory RVCT6: RAM 0x20800000 size 0x1800000
  memory RVCT9: RAM 0x200000 size 0x1000
  memory RVCT10: RAM 0x300000 size 0x1000
  scatter file: .\link_scripts\sdram.scat
  group Applications
    applications/: application.c
  group CPU
    ../../libcpu/arm/arm926/: context_rvds.S cpuport.c machine.c mmu.c stack.c start_rvds.S trap.c
    ../../libcpu/arm/common/: div0.c showmem.c
  group DeviceDrivers
    ../../components/drivers/core/: device.c
    ../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../components/drivers/serial/: dev_serial.c
  group Drivers
    drivers/: board.c led.c usart.c
    platform/: gpio.c interrupt.c reset.c rt_low_level_init.c system_clock.c timer0.c uart.c
  group Finsh
    ../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler_comm.c scheduler_up.c slab.c thread.c timer.c
  group Libc
    ../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
