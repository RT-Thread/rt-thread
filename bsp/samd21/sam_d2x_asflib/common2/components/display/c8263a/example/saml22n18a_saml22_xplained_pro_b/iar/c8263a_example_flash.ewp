# IAR project c8263a_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAML22N18A Atmel ATSAML22N18A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD=SAML22_XPLAINED_PRO_B; ARM_MATH_CM0PLUS=true; USART_CALLBACK_MODE=false; __SAML22N18A__; SYSTICK_MODE
  ICCARM.CCIncludePath2: ../../../../../../../sam0/drivers/system/power; ../../../../../../../sam0/drivers/system/reset; ../../../../../../../sam0/drivers/system/reset/reset_sam_l; ../../../../../../../sam0/utils/preprocessor; ../../../../../../../sam0/utils/cmsis/saml22/include; ../../../../../../services/delay; ../../../../../../../sam0/utils; ../../../../../../../sam0/drivers/sercom; ../../../../../../../sam0/drivers/port; ../../../../../../../sam0/boards; ../../../../../../../sam0/drivers/sercom/usart; ../../../../../../../common/services/serial; ../../../../../../../sam0/utils/cmsis/saml22/source; ../../../../../../../sam0/drivers/system/interrupt; ../../../../../../../sam0/drivers/system/power/power_sam_l; ../../../../../../../sam0/boards/saml22_xplained_pro_b; ../../../../../../../sam0/drivers/system/interrupt/system_interrupt_saml22; ../../../../../../../common/utils; ../../..; ../../../../../../services/delay/sam0; ../../../../../../../sam0/drivers/slcd; ../../../../../../../sam0/drivers/system/clock/clock_saml22; ../../../../../../../common/boards; ..; ../../../../../../../sam0/drivers/system/pinmux; ../../../../../../../sam0/drivers/system; ../../../../../../../sam0/utils/header_files; ../../../../../../../sam0/utils/stdio/stdio_serial; ../../../../../../../sam0/drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: c8263a_example_flash.bin
  ILINK.IlinkOutputFile: c8263a_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../sam0/utils/linker_scripts/saml22/iar/saml22n18a_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam0/drivers/system
    ../../../../../../../sam0/drivers/system/: system.c system.h
  group sam0/drivers/system/clock
    ../../../../../../../sam0/drivers/system/clock/: clock.h gclk.h
  group sam0/drivers/system/clock/clock_saml22
    ../../../../../../../sam0/drivers/system/clock/clock_saml22/: gclk.c clock.c clock_config_check.h clock_feature.h
  group sam0/drivers/system/interrupt
    ../../../../../../../sam0/drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_saml22
    ../../../../../../../sam0/drivers/system/interrupt/system_interrupt_saml22/: system_interrupt_features.h
  group sam0/drivers/system/pinmux
    ../../../../../../../sam0/drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../../../sam0/drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/power/power_sam_l
    ../../../../../../../sam0/drivers/system/power/power_sam_l/: power.h
  group sam0/drivers/system/reset/reset_sam_l
    ../../../../../../../sam0/drivers/system/reset/reset_sam_l/: reset.h
  group sam0/drivers/slcd
    ../../../../../../../sam0/drivers/slcd/: slcd.c slcd.h
  group sam0/drivers/port
    ../../../../../../../sam0/drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../../../sam0/drivers/port/quick_start/: qs_port_basic.h
  group sam0/drivers/sercom
    ../../../../../../../sam0/drivers/sercom/: sercom.c sercom_pinout.h sercom.h
  group sam0/drivers/sercom/usart
    ../../../../../../../sam0/drivers/sercom/usart/: usart.c usart.h
  group sam0/drivers/sercom/usart/quick_start_dma
    ../../../../../../../sam0/drivers/sercom/usart/quick_start_dma/: qs_usart_dma_use.h
  group sam0/drivers/sercom/usart/quick_start
    ../../../../../../../sam0/drivers/sercom/usart/quick_start/: qs_usart_basic_use.h
  group sam0/utils
    ../../../../../../../sam0/utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/saml22/source
    ../../../../../../../sam0/utils/cmsis/saml22/source/: system_saml22.c system_saml22.h
  group sam0/utils/cmsis/saml22/source/iar
    ../../../../../../../sam0/utils/cmsis/saml22/source/iar/: startup_saml22.c
  group sam0/utils/cmsis/saml22/include
    ../../../../../../../sam0/utils/cmsis/saml22/include/: saml22g17a.h saml22n18a.h saml22g18a.h saml22j17a.h saml22n16a.h saml22j18a.h saml22n17a.h saml22j16a.h saml22.h saml22g16a.h
  group sam0/utils/cmsis/saml22/include/instance
    ../../../../../../../sam0/utils/cmsis/saml22/include/instance/: tc0.h usb.h nvmctrl.h aes.h trng.h sercom3.h tc2.h freqm.h port.h slcd.h rtc.h ccl.h ac.h wdt.h sercom2.h tal.h osc32kctrl.h mtb.h eic.h mclk.h rstc.h sercom4.h pac.h evsys.h sercom5.h supc.h sercom0.h gclk.h tc3.h tcc0.h adc.h tc1.h dmac.h oscctrl.h sercom1.h pm.h dsu.h
  group sam0/utils/cmsis/saml22/include/component
    ../../../../../../../sam0/utils/cmsis/saml22/include/component/: mclk.h nvmctrl.h freqm.h osc32kctrl.h dmac.h usb.h ac.h trng.h rstc.h evsys.h supc.h port.h tcc.h ccl.h aes.h pac.h gclk.h mtb.h tc.h slcd.h eic.h adc.h tal.h wdt.h oscctrl.h pm.h sercom.h dsu.h rtc.h
  group sam0/utils/cmsis/saml22/include/pio
    ../../../../../../../sam0/utils/cmsis/saml22/include/pio/: saml22n17a.h saml22g16a.h saml22g17a.h saml22j17a.h saml22g18a.h saml22j18a.h saml22n18a.h saml22j16a.h saml22n16a.h
  group sam0/utils/stdio
    ../../../../../../../sam0/utils/stdio/: write.c read.c
  group sam0/utils/stdio/stdio_serial
    ../../../../../../../sam0/utils/stdio/stdio_serial/: stdio_serial.h
  group sam0/utils/preprocessor
    ../../../../../../../sam0/utils/preprocessor/: mrepeat.h mrecursion.h tpaste.h preprocessor.h stringz.h
  group sam0/utils/header_files
    ../../../../../../../sam0/utils/header_files/: io.h
  group sam0/boards/saml22_xplained_pro_b
    ../../../../../../../sam0/boards/saml22_xplained_pro_b/: board_init.c saml22_xplained_pro_b.h
  group common2/components/display/c8263a
    ../../../: c8263a.c c8263a.h
  group common2/components/display/c8263a/example
    ../../: c8263a_example.c
  group common2/components/display/c8263a/example/saml22n18a_saml22_xplained_pro_b
    ../: conf_board.h conf_slcd.h conf_clocks.h config_c8263a.h
  group common2/components/display/c8263a/example/saml22n18a_saml22_xplained_pro_b/iar
    ./: asf.h
  group common2/services/delay
    ../../../../../../services/delay/: delay.h
  group common2/services/delay/sam0
    ../../../../../../services/delay/sam0/: systick_counter.c systick_counter.h
  group common/utils
    ../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/serial
    ../../../../../../../common/services/serial/: serial.h
  group common/services/serial/sam0_usart
    ../../../../../../../common/services/serial/sam0_usart/: usart_serial.h
  group common/boards
    ../../../../../../../common/boards/: board.h
