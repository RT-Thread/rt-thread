# IAR project project.ewp, settings and files
configuration rt-thread (ARM, debug)
  General.OGChipSelectEditMenu: STM32L552ZE ST STM32L552ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: STM32U575xx; __RTTHREAD__; USE_HAL_DRIVER
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\components\libc\compilers\common\nogcc; ..\..\..\components\finsh; ..\..\..\libcpu\arm\common; ..\..\..\components\drivers\include; ..\..\..\examples\utest\testcases\kernel; .; ..\..\..\libcpu\arm\cortex-m33; applications; ..\libraries\STM32U5xx_HAL\CMSIS\Include; ..\libraries\HAL_Drivers\config; board; ..\..\..\components\libc\compilers\common; ..\..\..\components\libc\posix\io\poll; board\CubeMX_Config\Inc; ..\..\..\include; ..\libraries\STM32U5xx_HAL\STM32U5xx_HAL_Driver\Inc; ..\libraries\HAL_Drivers; ..\libraries\STM32U5xx_HAL\CMSIS\Device\ST\STM32U5xx\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../../rtthread.bin
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: main.c
  group CPU
    ../../../libcpu/arm/common/: div0.c showmem.c backtrace.c
    ../../../libcpu/arm/cortex-m33/: trustzone.c context_iar.S cpuport.c syscall_iar.S
  group DeviceDrivers
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/src/: waitqueue.c dataqueue.c workqueue.c ringblk_buf.c pipe.c completion.c ringbuffer.c
  group Drivers
    ../libraries/STM32U5xx_HAL/CMSIS/Device/ST/STM32U5xx/Source/Templates/iar/: startup_stm32u575xx.s
    board/CubeMX_Config/Src/: stm32u5xx_hal_msp.c
    board/: board.c
    ../libraries/HAL_Drivers/: drv_gpio.c drv_usart.c drv_common.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c cmd.c
  group Kernel
    ../../../src/: timer.c thread.c ipc.c clock.c object.c device.c idle.c components.c mem.c irq.c mempool.c kservice.c scheduler.c
  group libc
    ../../../components/libc/compilers/common/: time.c
  group Libraries
    ../libraries/STM32U5xx_HAL/STM32U5xx_HAL_Driver/Src/: stm32u5xx_hal_uart.c stm32u5xx_hal.c stm32u5xx_hal_crc.c stm32u5xx_hal_icache.c stm32u5xx_hal_uart_ex.c stm32u5xx_hal_dma.c stm32u5xx_hal_usart.c stm32u5xx_hal_pwr.c stm32u5xx_hal_rcc.c stm32u5xx_hal_gpio.c stm32u5xx_hal_rng.c stm32u5xx_hal_cortex.c stm32u5xx_hal_cryp.c stm32u5xx_hal_crc_ex.c stm32u5xx_hal_rcc_ex.c stm32u5xx_hal_usart_ex.c stm32u5xx_hal_cryp_ex.c stm32u5xx_hal_pwr_ex.c stm32u5xx_hal_comp.c stm32u5xx_hal_dma_ex.c stm32u5xx_hal_exti.c
    ../libraries/STM32U5xx_HAL/CMSIS/Device/ST/STM32U5xx/Source/Templates/: system_stm32u5xx.c
