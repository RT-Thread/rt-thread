# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MSP432P401Y Texas Instruments
  pack: TexasInstruments.MSP432P4xx_DFP.3.2.6
  cpu: IRAM(0x20000000,0x00040000) IRAM2(0x01000000,0x00040000) IROM(0x00000000,0x00100000) IROM2(0x00200000,0x00008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk, __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND, RT_USING_ARMLIBC, __MSP432E401Y__, __STDC_LIMIT_MACROS, RT_USING_LIBC
  c include: libraries\msp432e4\driverlib\inc;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\drivers\include;libraries\Drivers\CMSIS\Include;..\..\components\drivers\phy;..\..\components\drivers\smp_call;..\..\components\finsh;..\..\components\libc\posix\io\poll;libraries\Drivers;..\..\components\libc\posix\io\epoll;..\..\components\drivers\include;.;..\..\components\drivers\include;..\..\include;..\..\components\libc\posix\ipc;..\..\libcpu\arm\cortex-m4;libraries\msp432e4\driverlib;..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\components\libc\compilers\common\extension;applications;..\..\components\drivers\include;..\..\components\libc\posix\io\eventfd;board;..\..\libcpu\arm\common;..\..\components\libc\compilers\common\include;libraries\msp432e4\inc;..\..\components\net\utest;libraries\Drivers\config
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x1000000 size 0x40000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group CPU
    ../../libcpu/arm/common/: div0.c showmem.c
    ../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../components/drivers/core/: device.c
    ../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../components/drivers/pin/: dev_pin.c
    ../../components/drivers/serial/: dev_serial.c
  group Drivers
    board/: board.c
    libraries/msp432e4/startup_system_files/keil/: startup_msp432e401y_uvision.s
    libraries/Drivers/: drv_gpio.c drv_uart.c
  group Finsh
    ../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group Libc
    ../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
  group Libraries
    libraries/msp432e4/startup_system_files/: system_msp432e401y.c
    libraries/msp432e4/driverlib/: sysctl.c systick.c interrupt.c fpu.c cpu.c gpio.c uart.c
