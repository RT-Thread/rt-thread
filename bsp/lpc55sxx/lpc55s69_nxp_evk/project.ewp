# IAR project project.ewp, settings and files
configuration rtthread-lpc55s6x (ARM, debug)
  General.OGChipSelectEditMenu: LPC55S66_core0 NXP LPC55S66_core0
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: ARM_MATH_CM33; RT_USING_ARM_LIBC; CPU_LPC55S69JBD100_cm33_core0; __RTTHREAD__
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: board\MCUX_Config\board; ..\..\..\libcpu\arm\common; ..\..\..\libcpu\arm\cortex-m4; ..\Libraries\LPC55S6X\LPC55S6X; ..\Libraries\drivers; ..\Libraries\drivers\config; ..\..\..\components\drivers\include; ..\Libraries\LPC55S6X\middleware\sdmmc\inc; ..\..\..\examples\utest\testcases\kernel; ..\Libraries\LPC55S6X\components\codec; .; applications; ..\..\..\components\finsh; board; ..\Libraries\LPC55S6X\middleware\sdmmc\port; ..\..\..\components\libc\compilers\common; ..\Libraries\LPC55S6X\CMSIS\Include; ..\..\..\include; ..\Libraries\LPC55S6X\LPC55S6X\drivers; ..\..\..\components\libc\compilers\common\nogcc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: project.srec
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: board\linker_scripts\LPC55S69_cm33_core0_flash_iar.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Applications
    applications/: main.c
  group CPU
    ../../../libcpu/arm/common/: div0.c showmem.c backtrace.c
    ../../../libcpu/arm/cortex-m4/: context_iar.S cpuport.c
  group DeviceDrivers
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/src/: pipe.c workqueue.c waitqueue.c completion.c dataqueue.c ringblk_buf.c ringbuffer.c
  group Drivers
    board/MCUX_Config/board/: pin_mux.c clock_config.c
    board/: board.c
    ../Libraries/drivers/: drv_pin.c drv_key.c drv_led.c drv_uart.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c cmd.c
  group Kernel
    ../../../src/: thread.c components.c mempool.c kservice.c idle.c object.c device.c timer.c ipc.c scheduler.c irq.c clock.c mem.c
  group Libraries
    ../Libraries/LPC55S6X/LPC55S6X/drivers/: fsl_hashcrypt.c fsl_usart_dma.c fsl_spi_dma.c fsl_cmp.c fsl_utick.c fsl_power.c fsl_i2s_dma.c fsl_gpio.c fsl_casper.c fsl_clock.c fsl_reset.c fsl_sctimer.c fsl_common.c fsl_rtc.c fsl_crc.c fsl_sdif.c fsl_plu.c fsl_mrt.c fsl_i2s.c fsl_spi.c fsl_ctimer.c fsl_gint.c fsl_dma.c fsl_sysctl.c fsl_flexcomm.c fsl_pint.c fsl_powerquad_basic.c fsl_usart.c fsl_puf.c fsl_rng.c fsl_lpadc.c fsl_inputmux.c fsl_i2c_dma.c fsl_prince.c fsl_i2c.c fsl_wwdt.c fsl_anactrl.c fsl_iap.c fsl_ostimer.c
    ../Libraries/LPC55S6X/middleware/sdmmc/port/sdif/rt_thread/: fsl_sdmmc_host.c fsl_sdmmc_event.c
    ../Libraries/LPC55S6X/LPC55S6X/iar/: iar_lib_power_cm33_core0.a startup_LPC55S69_cm33_core0.s
    ../Libraries/LPC55S6X/middleware/sdmmc/src/: fsl_sd.c fsl_sdmmc_common.c
    ../Libraries/LPC55S6X/LPC55S6X/: system_LPC55S69_cm33_core0.c
