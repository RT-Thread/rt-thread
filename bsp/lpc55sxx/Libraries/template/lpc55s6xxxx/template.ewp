# IAR project template.ewp, settings and files
configuration rtthread-lpc55s6x (ARM, debug)
  General.OGChipSelectEditMenu: LPC55S66_core0 NXP LPC55S66_core0
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: ARM_MATH_CM33; RT_USING_ARM_LIBC
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: project.srec
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: board\linker_scripts\LPC55S69_cm33_core0_flash_iar.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
