# Keil uVision project template.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: R7FA2L1AB2DFM Renesas
  pack: Renesas.RA_DFP.3.6.0
  cpu: CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: rtthread +hex
  c flags: Optim=6 OneElfS=1 v6Lang=3 v6LangP=3
  c misc: -Wno-license-management -Wunused -Wuninitialized -Wall -Wmissing-declarations  -Wpointer-arith -Waggregate-return -Wfloat-equal
  library: MicroLIB
  scatter file: .\script\fsp.scat
  link misc: --entry=Reset_Handler --no_startup --via=".\script\ac6\fsp_keep.via"
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_entry.c pm_test.c
software components: Flex Software:RA Configuration 1.0.0
