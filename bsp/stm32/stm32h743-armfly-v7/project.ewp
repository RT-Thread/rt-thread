# IAR project project.ewp, settings and files
configuration rtthread (ARM, debug)
  General.OGChipSelectEditMenu: STM32H743II ST STM32H743II
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 0
  ICCARM.CCDefines: CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; STM32H743xx; __RTTHREAD__; USE_HAL_DRIVER; __RT_IPC_SOURCE__; __RT_KERNEL_SOURCE__
  ICCARM.CCIncludePath2: ..\..\..\libcpu\arm\cortex-m7; ..\libraries\STM32H7xx_HAL\STM32H7xx_HAL_Driver\Inc\Legacy; applications; ..\..\..\components\libc\compilers\common\include; board\CubeMX_Config\Inc; ..\..\..\components\libc\posix\ipc; ..\..\..\include; ..\..\..\components\libc\compilers\common\extension; ..\libraries\HAL_Drivers\drivers\config; .; ..\libraries\STM32H7xx_HAL\CMSIS\Device\ST\STM32H7xx\Include; ..\..\..\components\finsh; ..\libraries\HAL_Drivers\CMSIS\Include; ..\libraries\STM32H7xx_HAL\STM32H7xx_HAL_Driver\Inc; ..\libraries\HAL_Drivers; ..\..\..\components\libc\posix\io\poll; ..\..\..\components\libc\posix\io\eventfd; ..\..\..\components\drivers\smp_call; ..\..\..\components\drivers\phy; ..\libraries\HAL_Drivers\drivers; ..\..\..\components\drivers\include; board; ..\..\..\libcpu\arm\common; ..\..\..\components\libc\posix\io\epoll; ..\..\..\components\libc\compilers\common\extension\fcntl\octal
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../../rtthread.bin
  ILINK.IlinkOutputFile: template.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG; CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; STM32H743xx; __RTTHREAD__; USE_HAL_DRIVER; __RT_IPC_SOURCE__; __RT_KERNEL_SOURCE__
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: main.c
  group Compiler
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/pin/: dev_pin.c
    ../../../components/drivers/serial/: dev_serial.c
  group Drivers
    ../libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32H7xx/Source/Templates/iar/: startup_stm32h743xx.s
    board/CubeMX_Config/Src/: stm32h7xx_hal_msp.c
    board/: board.c
    ../libraries/HAL_Drivers/drivers/: drv_gpio.c drv_usart.c
    ../libraries/HAL_Drivers/: drv_common.c
  group Finsh
    ../../../components/finsh/: shell.c msh_parse.c msh.c cmd.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    ../../../src/klibc/: rt_vsscanf.c kstring.c kstdio.c rt_vsnprintf_tiny.c kerrno.c
  group libcpu
    ../../../libcpu/arm/common/: div0.c showmem.c
    ../../../libcpu/arm/cortex-m7/: context_iar.S cpu_cache.c cpuport.c
  group Libraries
    ../libraries/STM32H7xx_HAL/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_uart.c stm32h7xx_hal_cryp.c stm32h7xx_hal_cec.c stm32h7xx_hal_mdma.c stm32h7xx_hal_rng.c stm32h7xx_hal_pwr.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_comp.c stm32h7xx_hal_dma.c stm32h7xx_hal_sram.c stm32h7xx_hal_usart.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_gpio.c stm32h7xx_hal_crc.c stm32h7xx_hal_cryp_ex.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c
    ../libraries/STM32H7xx_HAL/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
