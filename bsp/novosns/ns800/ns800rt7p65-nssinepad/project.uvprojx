# Keil uVision project project.uvprojx, settings and files
target rt-thread (6190000::V6.19::ARMCLANG)
  device: NS800RT7P65D-DHQFBY2 Novosense
  pack: NOVOSENSE.NS800RT7XXX.0.5.2
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x00000000,0x00020000) IROM(0x08000000,0x00080000) IROM2(0x08080000,0x00080000) XRAM(0x20100000,0x00020000) XRAM2(0x20120000,0x00020000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NS800RT7P65X DUAL_CORE_ENABLE=0 SYSCLK_USE_PLL SYSCLK_SOURCE_USE_HXTL PLLCLK_SOURCE_USE_HXTL RT_USING_ARMLIBC, RT_USING_LIBC, NS800RT7P65X, USE_HAL_DRIVER, __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND, __STDC_LIMIT_MACROS
  c misc: -Wno-tautological-constant-out-of-range-compare
  c include: ..\..\..\components\drivers\include;..\..\..\components\libc\compilers\common\extension;..\..\..\components\libc\posix\io\poll;applications;..\..\..\components\net\utest;.;..\..\..\components\drivers\include;..\..\..\libcpu\arm\common;..\..\..\components\drivers\phy;..\..\..\include;..\..\..\components\drivers\include;..\libraries\HAL_Drivers\drivers\config;..\..\..\components\libc\compilers\common\include;..\..\..\components\libc\posix\ipc;..\..\..\components\libc\posix\io\epoll;..\libraries\HAL_Drivers\drivers;..\..\..\components\drivers\include;..\..\..\components\finsh;..\..\..\components\drivers\include;..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\components\drivers\smp_call;..\libraries\HAL_Drivers;.\packages\novosns-series\NS800RT7XXX\StdDriver\Inc;..\..\..\components\drivers\include;..\..\..\libcpu\arm\cortex-m7;packages\CMSIS-Core-latest\Include;board;..\..\..\components\libc\posix\io\eventfd;.\packages\novosns-series\NS800RT7XXX\Device\Inc;.\packages\novosns-series\NS800RT7XXX\StdDriver\Inc\ti;..\..\..\components\drivers\can
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT5: ROM 0x8080000 size 0x80000
  memory RVCT6: RAM 0x20100000 size 0x20000
  memory RVCT7: RAM 0x20120000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
    ./applications/: rt_ecap.c rt_can.c
  group CPU
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m7/: context_rvds.S cpu_cache.c cpuport.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/pin/: dev_pin.c
    ../../../components/drivers/serial/: dev_serial.c
    ../../../components/drivers/can/: dev_can.c
  group Drivers
    ../libraries/HAL_Drivers/drivers/: drv_uart.c drv_gpio.c drv_ecap.c drv_can.c
    ../libraries/HAL_Drivers/: drv_common.c
    board/: board.c
  group Finsh
    ../../../components/finsh/: cmd.c msh.c msh_file.c msh_parse.c shell.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group Libc
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
  group NS800RT7-CMSIS
    ./packages/novosns-series/NS800RT7XXX/Device/Src/: system_NS800RT7xxx.c
    ./packages/novosns-series/NS800RT7XXX/Device/Src/arm/: startup_NS800RT7xxx.s
  group NS800RT7-HAL
    ./packages/novosns-series/NS800RT7XXX/StdDriver/Src/: crc.c debug.c flash.c gpio.c interrupt.c rcc.c sram.c syscon.c uart.c xbar.c exti.c dmamux.c edma.c ecap.c flexcan.c
