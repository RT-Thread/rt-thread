# IAR project fm3_easy_kit.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MB9BF506 Fujitsu MB9BF506
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ; CMSIS; ..\..\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: fm3_easy_kit.out
  ILINK.IlinkIcfFile: D:\work\RTT\FM3\20110303\SVN\bsp\fm3\mb9bf500r.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group CMSIS
    CMSIS/: core_cm3.c system_mb9bf50x.c
  group FM3
    ../../libcpu/arm/fm3/: context_iar.S cpuport.c fault_iar.S start_iar.S
  group Kernel
    ../../src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c module.c object.c rtm.c scheduler.c slab.c thread.c timer.c
  group Startup
    ./: application.c board.c startup.c
