# Keil uVision project lpc17rt-thread.uvproj, settings and files
target RT-Thread LPC1700 (ARM-ADS)
  device: LPC1766 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x3FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: lpc17rt-thread
  c flags: Optim=1
  c include: .;..\..\include;..\..\libcpu\arm\lpc17xx;.\Libraries\CMSIS\Core\CM3;.\Libraries\LPC17xx_StdPeriph_Drivers\include;..\..\finsh;..\..\filesystem\dfs\include;..\..\filesystem\dfs\;..\..\rtgui\include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Startup
    ./: board.h rtconfig.h board.c startup.c uart.c application.c
  group CMSIS
    ./CMSIS/: core_cm3.c system_LPC17xx.c
  group Kernel
    ../../src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c slab.c thread.c timer.c
  group LPC1700
    ../../libcpu/arm/lpc17xx/: cpu.c fault.c interrupt.c stack.c context_rvds.S fault_rvds.S start_rvds.S
  group finish
    ../../finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c shell.c symbol.c
