# Keil uVision project template.uvprojx, settings and files
target rtthread (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: rtthread +hex
  AfterMake: fromelf.exe --bin -o  .//@L.bin  ./build/@L.axf
  c flags: Optim=1 OneElfS=1 uC99=1
  memory RVCT4: ROM 0x70020000 size 0x200000
  memory RVCT9: RAM 0x70220000 size 0x5dffff
