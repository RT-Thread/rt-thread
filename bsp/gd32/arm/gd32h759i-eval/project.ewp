# IAR project project.ewp, settings and files
configuration rtthread (ARM, debug)
  General.OGChipSelectEditMenu: STM32H743II ST STM32H743II
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 0
  ICCARM.CCDefines: GD32H7XX; USE_STDPERIPH_DRIVER; __RTTHREAD__; CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; _DLIB_FILE_DESCRIPTOR; __RT_IPC_SOURCE__; __RT_KERNEL_SOURCE__
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\libraries\gd32_drivers; ..\..\..\..\components\libc\compilers\common\extension\fcntl\octal; ..\..\..\..\components\libc\posix\ipc; ..\..\..\..\components\dfs\dfs_v1\filesystems\devfs; ..\..\..\..\components\libc\posix\io\poll; applications; .; ..\..\..\..\components\libc\compilers\common\extension; packages\gd32-arm-cmsis-latest\GD32H7xx; ..\libraries\gd32_drivers\config; ..\..\..\..\components\drivers\smp_call; ..\..\..\..\components\libc\posix\io\eventfd; ..\..\..\..\components\net\utest; ..\..\..\..\components\dfs\dfs_v1\include; ..\..\..\..\libcpu\arm\cortex-m7; ..\..\..\..\libcpu\arm\common; ..\..\..\..\components\drivers\include; ..\..\..\..\components\finsh; packages\gd32-arm-cmsis-latest\GD32H7xx\GD\GD32H7xx\Include; ..\..\..\..\components\drivers\phy; ..\..\..\..\components\libc\posix\io\epoll; ..\..\..\..\include; board; ..\..\..\..\components\libc\compilers\common\include; packages\gd32-arm-series-latest\GD32H7xx\GD32H7xx_standard_peripheral\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../../rtthread.bin
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: main.c
  group Compiler
    ../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../../components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
  group DeviceDrivers
    ../../../../components/drivers/core/: device.c
    ../../../../components/drivers/i2c/: dev_i2c_bit_ops.c dev_i2c_core.c dev_i2c_dev.c
    ../../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../components/drivers/pin/: dev_pin.c
    ../../../../components/drivers/serial/: dev_serial.c
  group Drivers
    board/: board.c
    ../libraries/gd32_drivers/: drv_gpio.c drv_usart.c
  group Filesystem
    ../../../../components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    ../../../../components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    ../../../../components/finsh/: msh.c msh_parse.c shell.c cmd.c msh_file.c
  group Kernel
    ../../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    ../../../../src/klibc/: kerrno.c kstring.c rt_vsscanf.c rt_vsnprintf_tiny.c kstdio.c
  group libcpu
    ../../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../../libcpu/arm/cortex-m7/: context_iar.S cpu_cache.c cpuport.c
  group Libraries
    packages/gd32-arm-cmsis-latest/GD32H7xx/GD/GD32H7xx/Source/IAR/: startup_gd32h7xx.s
    packages/gd32-arm-cmsis-latest/GD32H7xx/GD/GD32H7xx/Source/: system_gd32h7xx.c
    packages/gd32-arm-series-latest/GD32H7xx/GD32H7xx_standard_peripheral/Source/: gd32h7xx_dma.c gd32h7xx_exti.c gd32h7xx_gpio.c gd32h7xx_i2c.c gd32h7xx_misc.c gd32h7xx_pmu.c gd32h7xx_rcu.c gd32h7xx_syscfg.c gd32h7xx_usart.c
