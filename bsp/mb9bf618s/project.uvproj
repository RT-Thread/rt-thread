# Keil uVision project project.uvproj, settings and files
target rtthread (ARM-ADS)
  device: MB9BF618S Fujitsu Semiconductors
  cpu: IRAM(0x20000000-0x2000FFFF) IRAM2(0x1FFF0000-0x1FFFFFFF) IROM(0x00000000-0x000FFFFF) CLOCK(4000000) CPUTYPE("Cortex-M3")
  output: rtthread-fm3
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1
  c define: MB9B610S, __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND
  c include: applications;.;CMSIS\Include;CMSIS\DeviceSupport\fujitsu\mb9bf61x;..\..\libcpu\arm\common;..\..\libcpu\arm\cortex-m3;drivers;..\..\components\finsh;.;..\..\include;..\..\components\libc\compilers\common;..\..\components\libc\compilers\common\nogcc;..\..\examples\utest\testcases\kernel
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x20000
  scatter file: rtthread-fm3.sct
  group Applications
    applications/: startup.c application.c
  group CMSIS
    CMSIS/DeviceSupport/fujitsu/mb9bf61x/: system_mb9bf61x.c
    CMSIS/DeviceSupport/fujitsu/mb9bf61x/startup/arm/: startup_mb9bf61x.S
  group CPU
    ../../libcpu/arm/common/: showmem.c div0.c backtrace.c
    ../../libcpu/arm/cortex-m3/: context_rvds.S cpuport.c
  group Drivers
    drivers/: board.c serial.c led.c
  group Finsh
    ../../components/finsh/: shell.c msh.c
  group Kernel
    ../../src/: idle.c thread.c irq.c ipc.c components.c timer.c device.c mempool.c object.c mem.c scheduler.c clock.c kservice.c
