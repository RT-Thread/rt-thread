# Keil uVision project project.uvprojx, settings and files
target rtthread-m460 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: M467HJHAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.25
  cpu: IRAM(0x20000000,0x80000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: rtthread +hex
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 v6Lang=1 v6LangP=3
  c define: __STDC_LIMIT_MACROS, __CLK_TCK=RT_TICK_PER_SECOND, RT_USING_ARMLIBC, __RTTHREAD__, RT_USING_LIBC
  c misc: --c99 --diag_suppress=66,1296,186 --diag_suppress=1,177,550 --gnu
  c include: ..\..\..\components\drivers\audio;..\..\..\components\net\sal\impl;..\..\..\components\drivers\smp_call;..\..\..\components\libc\compilers\common\extension;..\..\..\components\drivers\include;packages\nuvoton-cmsis-latest\m460_m2354\Include;..\..\..\components\drivers\phy;..\..\..\components\finsh;..\libraries\nu_packages\Demo;..\..\..\components\drivers\include;..\..\..\components\drivers\spi;.;..\..\..\components\libc\posix\io\poll;..\..\..\components\drivers\include;..\..\..\components\fal\inc;board;..\..\..\libcpu\arm\cortex-m4;..\..\..\components\net\lwip\lwip-2.1.2\src\include\netif;..\..\..\components\libc\posix\io\eventfd;..\..\..\components\dfs\dfs_v1\filesystems\elmfat;..\libraries\nu_packages\TPC;packages\at_device-latest\inc;..\..\..\components\net\lwip\port;..\libraries\nu_packages\NCT7717U;..\..\..\components\net\sal\include\socket;..\..\..\components\net\sal\include;..\..\..\components\drivers\spi\sfud\inc;..\libraries\m460\rtt_port;..\..\..\components\net\netdev\include;..\..\..\components\net\at\at_socket;..\..\..\components\utilities\utest;..\..\..\components\drivers\include;packages\nuvoton-series-latest\M460\Device\Nuvoton\m460\Include;..\..\..\components\drivers\hwcrypto;..\libraries\nu_packages\NuUtils\inc;..\..\..\components\libc\posix\io\epoll;..\..\..\components\net\lwip\lwip-2.1.2\src\include;..\..\..\components\libc\posix\ipc;board\NuPinConfig;..\..\..\components\legacy\usb\usbhost\class;..\..\..\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\legacy\usb\usbhost\core;..\..\..\components\net\at\include;..\..\..\components\drivers\include;..\..\..\libcpu\arm\common;..\..\..\components\legacy\include;..\..\..\components\libc\compilers\common\include;..\..\..\components\utilities\ulog;applications;..\..\..\components\legacy\dfs;..\..\..\components\drivers\include;..\libraries\m460\rtt_port\emac;..\..\..\components\drivers\include;..\..\..\components\drivers\include;packages\nuvoton-series-latest\M460\USBHostLib\inc;packages\at_device-latest\class\esp8266;..\..\..\components\drivers\sdio\sdhci\include;..\..\..\components\dfs\dfs_v1\filesystems\devfs;..\..\..\components\net\sal\include\socket\sys_socket;..\..\..\components\net\sal\include\dfs_net;..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\components\legacy;packages\nuvoton-series-latest\M460\StdDriver\inc;..\..\..\components\legacy\usb\usbhost;..\..\..\components\dfs\dfs_v1\include;..\..\..\components\legacy\usb\usbhost\include;..\..\..\components\drivers\include;..\..\..\components\legacy\usb\usbdevice;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x80000
  scatter file: .\linking_scripts\m460_flash.sct
  group Applications
    applications/: main.c mnt.c
  group AT
    ../../../components/net/at/src/: at_utils.c at_cli.c at_client.c
    ../../../components/net/at/at_socket/: at_socket.c
  group at_device
    packages/at_device-latest/samples/: at_sample_esp8266.c
    packages/at_device-latest/class/esp8266/: at_device_esp8266.c at_socket_esp8266.c
    packages/at_device-latest/src/: at_device.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../components/drivers/audio/: dev_audio.c dev_audio_pipe.c
    ../../../components/drivers/block/: blk.c blk_dev.c blk_dfs.c blk_partition.c
    ../../../components/drivers/block/partitions/: dfs.c efi.c
    ../../../components/drivers/can/: dev_can.c
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/hwcrypto/: hw_crc.c hw_hash.c hw_rng.c hw_symmetric.c hwcrypto.c
    ../../../components/drivers/clock_time/: clock_timer.c
    ../../../components/drivers/i2c/: dev_i2c_bit_ops.c dev_i2c_core.c dev_i2c_dev.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/misc/: rt_drv_pwm.c rt_inputcapture.c
    ../../../components/drivers/pin/: dev_pin.c
    ../../../components/drivers/rtc/: dev_rtc.c
    ../../../components/drivers/sdio/: dev_block.c dev_mmc.c dev_mmcsd_core.c dev_sd.c dev_sdio.c
    ../../../components/drivers/sensor/v2/: sensor.c sensor_cmd.c
    ../../../components/drivers/serial/: dev_serial.c
    ../../../components/drivers/spi/: dev_qspi_core.c dev_spi.c dev_spi_core.c dev_spi_flash_sfud.c
    ../../../components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    ../../../components/drivers/watchdog/: dev_watchdog.c
  group Drivers
    ../libraries/m460/rtt_port/: drv_bpwm.c drv_bpwm_capture.c drv_canfd.c drv_ccap.c drv_common.c drv_crc.c drv_crypto.c drv_dac.c drv_eadc.c drv_ebi.c drv_ecap.c drv_epwm.c drv_epwm_capture.c drv_eqei.c drv_fmc.c drv_gpio.c drv_hsotg.c drv_hsusbd.c drv_i2c.c drv_i2s.c drv_pdma.c drv_qspi.c drv_rtc.c drv_scuart.c drv_sdh.c drv_sdio.c drv_softi2c.c drv_spi.c drv_spii2s.c drv_timer.c drv_tpwm.c drv_trng.c drv_uart.c drv_ui2c.c drv_usbd.c drv_usbhost.c drv_uspi.c drv_uuart.c drv_wdt.c
    board/NuPinConfig/: nutool_pincfg.c
    board/: board_dev.c nutool_modclkcfg.c
    packages/nuvoton-series-latest/M460/Device/Nuvoton/m460/Source/ARM/: startup_m460.s
    packages/nuvoton-series-latest/M460/Device/Nuvoton/m460/Source/: system_m460.c
    ../libraries/m460/rtt_port/emac/: drv_emac.c mii.c synopGMAC_Dev.c synopGMAC_network_interface.c synopGMAC_plat.c
  group Fal
    ../../../components/fal/src/: fal_partition.c fal_rtt.c fal.c fal_flash.c
    ../../../components/fal/samples/porting/: fal_flash_sfud_port.c
  group Filesystem
    ../../../components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    ../../../components/dfs/dfs_v1/filesystems/elmfat/: dfs_elm.c ff.c ffunicode.c
    ../../../components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    ../../../components/finsh/: msh.c msh_file.c msh_parse.c cmd.c shell.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c signal.c thread.c timer.c
  group klibc
    ../../../src/klibc/: kstdio.c rt_vsscanf.c kerrno.c rt_vsnprintf_std.c kstring.c
  group Legacy
    ../../../components/legacy/ipc/: workqueue_legacy.c
  group libcpu
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group Libraries
    packages/nuvoton-series-latest/M460/StdDriver/src/: nu_timer_pwm.c nu_crypto.c nu_sc.c nu_trng.c nu_hsusbd.c nu_eqei.c nu_timer.c nu_scuart.c nu_ccap.c nu_wwdt.c nu_keystore.c nu_bpwm.c nu_i2s.c nu_crc.c nu_qspi.c nu_uart.c nu_fmc.c nu_kpi.c nu_dac.c nu_spi.c nu_acmp.c nu_eadc.c nu_bmc.c nu_spim.c nu_ebi.c nu_usci_uart.c nu_i2c.c nu_clk.c nu_hbi.c nu_sys.c nu_sdh.c nu_usci_i2c.c nu_rtc.c nu_wdt.c nu_pdma.c nu_epwm.c nu_canfd.c nu_usci_spi.c nu_rng.c nu_ecap.c nu_gpio.c nu_usbd.c
  group lwIP
    ../../../components/net/lwip/lwip-2.1.2/src/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../components/net/lwip/lwip-2.1.2/src/apps/ping/: ping.c
    ../../../components/net/lwip/lwip-2.1.2/src/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../components/net/lwip/lwip-2.1.2/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../components/net/lwip/lwip-2.1.2/src/netif/: ethernet.c lowpan6.c
    ../../../components/net/lwip/port/: ethernetif.c sys_arch.c
  group m460_usbhostlib
    packages/nuvoton-series-latest/M460/USBHostLib/src/: mem_alloc.c ohci.c ehci_iso.c ehci.c usb_core.c
  group nu_pkgs_demo
    ../libraries/nu_packages/Demo/: slcd_show_tick.c usbd_cdc_vcom_echo.c smp_demo.c wormhole_demo.c ccap_demo.c usbd_hid_dance_mouse.c ccap_saver.c atdev_utils.c hwsem_counter.c
  group nu_pkgs_nct7717u
    ../libraries/nu_packages/NCT7717U/: sensor_nct7717u.c
  group POSIX
    ../../../components/libc/posix/io/poll/: poll.c select.c
  group rt_usbd
    ../../../components/legacy/usb/usbdevice/core/: usbdevice_core.c usbdevice.c
    ../../../components/legacy/usb/usbdevice/class/: mstorage.c
  group rt_usbh
    ../../../components/legacy/usb/usbhost/core/: driver.c usbhost_core.c hub.c usbhost.c
    ../../../components/legacy/usb/usbhost/class/: udisk.c mass.c
  group SAL
    ../../../components/net/netdev/src/: netdev.c netdev_ipaddr.c
    ../../../components/net/sal/dfs_net/: dfs_net.c
    ../../../components/net/sal/impl/: af_inet_at.c af_inet_lwip.c
    ../../../components/net/sal/socket/: net_netdb.c net_sockets.c
    ../../../components/net/sal/src/: sal_socket.c
  group UTest
    ../../../components/utilities/utest/: TC_uassert.c utest.c
  group Utilities
    ../../../components/utilities/ulog/backend/: console_be.c
    ../../../components/utilities/ulog/: ulog.c
software components: CMSIS:CORE 6.1.0
