# Keil uVision project project.uvprojx, settings and files
target rtthread-apollo2 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: AMAPH1KK-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.0.0
  cpu: IROM(0x00000000,0x100000) IRAM(0x10000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __STDC_LIMIT_MACROS, __RTTHREAD__, AM_PACKAGE_BGA, __CLK_TCK=RT_TICK_PER_SECOND, RT_USING_LIBC, RT_USING_ARMLIBC, AM_PART_APOLLO2
  c include: ..\..\libcpu\arm\cortex-m4;..\..\components\drivers\include;..\..\components\drivers\include;..\..\libcpu\arm\common;..\..\components\libc\posix\io\eventfd;applications;..\..\components\drivers\include;..\..\components\drivers\phy;..\..\components\dfs\dfs_v1\filesystems\devfs;..\..\components\dfs\dfs_v1\include;libraries\startup;..\..\components\libc\posix\io\poll;libraries\drivers;..\..\components\drivers\include;board;..\..\components\libc\posix\io\epoll;..\..\components\drivers\spi;..\..\components\libc\compilers\common\extension;..\..\components\drivers\include;libraries\startup\cmsis\include;..\..\components\net\utest;..\..\include;..\..\components\drivers\smp_call;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\libc\compilers\common\include;..\..\components\drivers\include;..\..\components\finsh;.;..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\components\libc\posix\ipc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x40000
  group Applications
    applications/: main.c
  group CPU
    ../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../components/drivers/core/: device.c
    ../../components/drivers/i2c/: dev_i2c_bit_ops.c dev_i2c_core.c dev_i2c_dev.c
    ../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../components/drivers/pin/: dev_pin.c
    ../../components/drivers/rtc/: dev_rtc.c
    ../../components/drivers/serial/: dev_serial.c
    ../../components/drivers/spi/: dev_spi.c dev_spi_core.c
  group Drivers
    board/: adc.c board.c flash.c gpio.c i2c.c led.c pdm.c pwm.c rtc.c smbus.c spi.c uart.c
  group Filesystem
    ../../components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    ../../components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    ../../components/finsh/: shell.c msh.c msh_parse.c cmd.c msh_file.c
  group Kernel
    ../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group Libc
    ../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
  group Libraries
    libraries/drivers/hal/: am_hal_adc.c am_hal_cachectrl.c am_hal_clkgen.c am_hal_ctimer.c am_hal_debug.c am_hal_flash.c am_hal_gpio.c am_hal_i2c_bit_bang.c am_hal_interrupt.c am_hal_iom.c am_hal_ios.c am_hal_mcuctrl.c am_hal_pdm.c am_hal_pwrctrl.c am_hal_queue.c am_hal_reset.c am_hal_rtc.c am_hal_stimer.c am_hal_sysctrl.c am_hal_uart.c am_hal_vcomp.c
    libraries/startup/arm/: startup_keil.s
