# Keil uVision project project.uvproj, settings and files
target rtthread (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: COMPONENT_CAT1A, RT_USING_LIBC, RT_USING_ARMLIBC, CY_USING_HAL, __CLK_TCK=RT_TICK_PER_SECOND, COMPONENT_BSP_DESIGN_MODUS, __STDC_LIMIT_MACROS, __RTTHREAD__, COMPONENT_CAT1, CY8C624ABZI_S2D44
  c include: ..\libraries\IFX_PSOC6_HAL\retarget-io;..\..\..\components\libc\compilers\common\extension;..\..\..\components\drivers\include;..\..\..\include;board;..\..\..\components\finsh;..\..\..\components\drivers\include;..\libraries\IFX_PSOC6_HAL\mtb_shared\usbdev;..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\libraries\IFX_PSOC6_HAL\mtb-hal-cat1\include_pvt;..\libraries\IFX_PSOC6_HAL\mtb-hal-cat1\include;..\libraries\IFX_PSOC6_HAL\mtb-hal-cat1\COMPONENT_CAT1A\include;libs\TARGET_CY8CKIT-062S2-43012;libs\TARGET_CY8CKIT-062S2-43012\COMPONENT_BSP_DESIGN_MODUS\GeneratedSource;..\libraries\IFX_PSOC6_HAL\capsense;..\libraries\HAL_Drivers;..\libraries\IFX_PSOC6_HAL\mtb_shared\serial-flash;.;..\libraries\IFX_PSOC6_HAL\core-lib\include;..\..\..\libcpu\arm\cortex-m4;..\..\..\components\drivers\include;..\..\..\libcpu\arm\common;..\libraries\IFX_PSOC6_HAL\mtb-pdl-cat1\cmsis\include;applications;..\libraries\IFX_PSOC6_HAL\mtb_shared\csdidac;..\..\..\components\libc\posix\ipc;..\libraries\IFX_PSOC6_HAL\mtb-pdl-cat1\devices\COMPONENT_CAT1A\include;..\..\..\components\libc\posix\io\stdio;..\..\..\components\libc\posix\io\poll;..\..\..\components\libc\compilers\common\include;..\libraries\IFX_PSOC6_HAL\mtb-pdl-cat1\drivers\include;..\libraries\HAL_Drivers\config;board\ports;..\libraries\IFX_PSOC6_HAL\psoc6cm0p
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdio.c cstdlib.c cstring.c ctime.c cwchar.c
  group CPU
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../../components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/serial/: serial.c
  group Drivers
    ../libraries/IFX_PSOC6_HAL/mtb-pdl-cat1/drivers/source/TOOLCHAIN_ARM/: cy_syslib_mdk.S
    board/: board.c
    ../libraries/HAL_Drivers/: drv_common.c drv_gpio.c drv_uart.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_up.c thread.c timer.c
  group Libraries
    ../libraries/IFX_PSOC6_HAL/mtb-pdl-cat1/drivers/source/: cy_sysint.c cy_scb_i2c.c cy_gpio.c cy_scb_uart.c cy_scb_common.c cy_prot.c cy_ipc_sema.c cy_ipc_drv.c cy_syslib.c cy_ipc_pipe.c cy_mcwdt.c cy_sysclk.c cy_systick.c cy_trigmux.c cy_syspm.c
    ../libraries/IFX_PSOC6_HAL/mtb-hal-cat1/COMPONENT_CAT1A/source/triggers/: cyhal_triggers_psoc6_02.c
    ../libraries/IFX_PSOC6_HAL/retarget-io/: cy_retarget_io.c
    ../libraries/IFX_PSOC6_HAL/psoc6cm0p/COMPONENT_CM0P_SLEEP/: psoc6_02_cm0p_sleep.c psoc6_01_cm0p_sleep.c psoc6_03_cm0p_sleep.c psoc6_04_cm0p_sleep.c
    ../libraries/IFX_PSOC6_HAL/mtb-hal-cat1/source/: cyhal_scb_common.c cyhal_clock.c cyhal_gpio.c cyhal_system.c cyhal_utils_psoc.c cyhal_utils.c cyhal_hwmgr.c cyhal_lptimer.c cyhal_irq_psoc.c cyhal_syspm.c cyhal_uart.c cyhal_interconnect.c
    ../libraries/IFX_PSOC6_HAL/mtb-hal-cat1/COMPONENT_CAT1A/source/pin_packages/: cyhal_psoc6_02_124_bga.c
    ../libraries/IFX_PSOC6_HAL/mtb-pdl-cat1/devices/COMPONENT_CAT1A/source/: cy_device.c
  group libs
    libs/TARGET_CY8CKIT-062S2-43012/: cybsp.c
    libs/TARGET_CY8CKIT-062S2-43012/COMPONENT_BSP_DESIGN_MODUS/GeneratedSource/: cycfg_clocks.c cycfg_capsense.c cycfg_system.c cycfg_routing.c cycfg_peripherals.c cycfg_dmas.c cycfg.c cycfg_connectivity_bt.c cycfg_pins.c cycfg_qspi_memslot.c
    libs/TARGET_CY8CKIT-062S2-43012/COMPONENT_CM4/: system_psoc6_cm4.c
    libs/TARGET_CY8CKIT-062S2-43012/COMPONENT_CM4/TOOLCHAIN_ARM/: startup_psoc6_02_cm4.S
