# Keil uVision project project.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: V85XX Generic
  pack: Vango.V85XX.4.0.2
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: template
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, RT_USING_ARMLIBC, __STDC_LIMIT_MACROS, RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND, USE_TARGET_DRIVER, V85XXP, __RTTHREAD__
  c include: ..\..\..\components\finsh;applications;..\..\..\components\libc\posix\ipc;..\..\..\components\libc\posix\io\eventfd;drivers;..\..\..\components\dfs\dfs_v1\include;..\..\..\components\drivers\phy;.;..\..\..\libcpu\arm\common;..\..\..\include;..\..\..\libcpu\arm\cortex-m0;..\..\..\components\libc\posix\io\epoll;..\..\..\components\drivers\include;..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\components\drivers\include;libraries\CMSIS;..\..\..\components\net\utest;..\..\..\components\drivers\include;..\..\..\components\libc\posix\io\poll;..\..\..\components\drivers\include;..\..\..\components\libc\compilers\common\extension;..\..\..\components\libc\compilers\common\include;..\..\..\components\drivers\smp_call;..\..\..\components\drivers\include;libraries\VangoV85xxP_standard_peripheral\Include;..\..\..\components\drivers\include;libraries\CMSIS\Vango\V85xxP\Include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Applications
    applications/: main.c
  group CPU
    ../../../libcpu/arm/common/: div0.c showmem.c
    ../../../libcpu/arm/cortex-m0/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/pin/: dev_pin.c
    ../../../components/drivers/serial/: dev_serial.c
  group Drivers
    drivers/: board.c drv_usart.c drv_gpio.c
  group Filesystem
    ../../../components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c msh_file.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group Libc
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
  group Vango_Lib
    libraries/VangoV85xxP_standard_peripheral/Source/: lib_adc.c lib_adc_tiny.c lib_ana.c lib_clk.c lib_cmp.c lib_crypt.c lib_dma.c lib_flash.c lib_gpio.c lib_i2c.c lib_iso7816.c lib_lcd.c lib_misc.c lib_pmu.c lib_pwm.c lib_rtc.c lib_spi.c lib_tmr.c lib_u32k.c lib_uart.c lib_version.c lib_wdt.c
    libraries/CMSIS/Vango/V85xxP/Source/: system_target.c lib_CodeRAM.c lib_cortex.c lib_LoadNVR.c
    libraries/CMSIS/Vango/V85xxP/Source/Keil5/: startup_target.S
