# IAR project template.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MB9BF506R Fujitsu MB9BF506R
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: .
  OBJCOPY.OOCOutputFile: project.srec
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: rtthread-mb9bf506.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
