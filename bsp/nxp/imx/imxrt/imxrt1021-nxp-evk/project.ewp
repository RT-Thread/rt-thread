# IAR project project.ewp, settings and files
configuration rtthread (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1021xxx5A NXP MIMXRT1021xxx5A
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; _DLIB_FILE_DESCRIPTOR; CPU_MIMXRT1021DAG5A; ENDIANNESS; STD=C99; SKIP_SYSCLK_INIT; EVK_MCIMXRM; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; __RTTHREAD__; __RT_IPC_SOURCE__; __RT_KERNEL_SOURCE__
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ..\..\..\..\..\components\finsh; xip; ..\..\..\..\..\components\libc\posix\ipc; ..\..\..\..\..\components\dfs\dfs_v1\include; ..\..\..\..\..\components\drivers\spi; ..\..\..\..\..\components\dfs\dfs_v1\filesystems\devfs; ..\..\..\..\..\components\dfs\dfs_v1\filesystems\elmfat; ..\libraries\MIMXRT1020\MIMXRT1021\drivers; ..\libraries\MIMXRT1020\CMSIS\Include; ..\..\..\..\..\components\libc\compilers\common\include; ..\..\..\..\..\components\libc\compilers\common\extension\fcntl\octal; ..\..\..\..\..\include; ..\..\..\..\..\components\libc\posix\io\eventfd; board; ..\..\..\..\..\components\libc\posix\io\poll; board\ports; ..\..\..\..\..\components\legacy\usb\usbdevice; .; ..\..\..\..\..\libcpu\arm\cortex-m7; ..\..\..\..\..\libcpu\arm\common; ..\libraries\drivers; ..\..\..\..\..\components\drivers\smp_call; ..\libraries\MIMXRT1020\MIMXRT1021; ..\..\..\..\..\components\drivers\include; ..\..\..\..\..\components\drivers\sdio\sdhci\include; applications; ..\..\..\..\..\components\libc\posix\io\epoll; ..\..\..\..\..\components\libc\compilers\common\extension; ..\..\..\..\..\components\drivers\phy; board\MCUX_Config
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: template.srec
  ILINK.IlinkOutputFile: rtthread.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Applications
    applications/: main.c
  group Compiler
    ../../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../../../components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
  group DeviceDrivers
    ../../../../../components/drivers/core/: device.c
    ../../../../../components/drivers/i2c/: dev_i2c_bit_ops.c dev_i2c_core.c dev_i2c_dev.c
    ../../../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../../components/drivers/misc/: adc.c rt_drv_pwm.c
    ../../../../../components/drivers/pin/: dev_pin.c
    ../../../../../components/drivers/rtc/: dev_rtc.c
    ../../../../../components/drivers/sdio/: dev_block.c dev_mmc.c dev_mmcsd_core.c dev_sd.c dev_sdio.c
    ../../../../../components/drivers/serial/: dev_serial.c
    ../../../../../components/drivers/spi/: dev_qspi_core.c dev_spi.c dev_spi_core.c
  group Drivers
    board/MCUX_Config/: clock_config.c dcd.c pin_mux.c
    board/: board.c
    ../libraries/drivers/: drv_common.c drv_gpio.c drv_uart.c
  group Filesystem
    ../../../../../components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    ../../../../../components/dfs/dfs_v1/filesystems/elmfat/: dfs_elm.c ff.c ffunicode.c
    ../../../../../components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    ../../../../../components/finsh/: cmd.c msh_parse.c msh_file.c shell.c msh.c
  group Kernel
    ../../../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    ../../../../../src/klibc/: rt_vsscanf.c kerrno.c kstring.c kstdio.c rt_vsnprintf_tiny.c
  group libcpu
    ../../../../../libcpu/arm/common/: div0.c showmem.c
    ../../../../../libcpu/arm/cortex-m7/: context_iar.S cpu_cache.c cpuport.c
  group Libraries
    ../libraries/MIMXRT1020/MIMXRT1021/drivers/: fsl_gpio.c fsl_common.c fsl_cache.c fsl_clock.c fsl_lpuart.c fsl_usdhc.c
    ../libraries/MIMXRT1020/MIMXRT1021/: system_MIMXRT1021.c
    ../libraries/MIMXRT1020/MIMXRT1021/iar/: startup_MIMXRT1021.s
  group rt_usbd
    ../../../../../components/legacy/usb/usbdevice/class/: mstorage.c cdc_vcom.c
    ../../../../../components/legacy/usb/usbdevice/core/: usbdevice_core.c usbdevice.c
  group xip
    xip/: fsl_flexspi_nor_boot.c fsl_flexspi_nor_flash.c
