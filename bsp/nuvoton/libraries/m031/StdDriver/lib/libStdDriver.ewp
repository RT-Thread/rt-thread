# IAR project libStdDriver.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M031AE series Nuvoton M031AE series
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: ARM_MATH_CM0
  ICCARM.CCDiagSuppress: Pa082,Pe550
  ICCARM.CCIncludePath2: ..\..\Device\Nuvoton\M031\Include; ..\..\CMSIS\Include; ..\inc; $PROJ_DIR$
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Template.srec
  ILINK.IlinkOutputFile: Template.out
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCOptLevel: 1
  OBJCOPY.OOCOutputFile: rtthread.bin
  ILINK.IlinkIcfFile: linking_scripts\m2354_flash.icf
  group src
    ../src/: nu_acmp.c nu_adc.c nu_bpwm.c nu_clk.c nu_crc.c nu_ebi.c nu_fmc.c nu_gpio.c nu_i2c.c nu_pdma.c nu_pwm.c nu_qspi.c nu_rtc.c nu_spi.c nu_sys.c nu_timer.c nu_uart.c nu_usbd.c nu_usci_i2c.c nu_usci_spi.c nu_usci_uart.c nu_wdt.c nu_wwdt.c
