# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MCXC444 NXP MCXC444
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; DEBUG; CPU_MCXC444VLH; __RTTHREAD__; __RT_IPC_SOURCE__; __RT_KERNEL_SOURCE__
  ICCARM.CCIncludePath2: ..\Libraries\drivers; ..\..\..\..\..\components\libc\compilers\common\extension\fcntl\octal; board\MCUX_Config\board; ..\..\..\..\..\components\libc\posix\io\poll; ..\..\..\..\..\components\drivers\spi; applications; ..\..\..\..\..\libcpu\arm\cortex-m0; ..\..\..\..\..\components\libc\posix\io\eventfd; ..\..\..\..\..\components\libc\compilers\common\include; ..\..\..\..\..\components\libc\compilers\common\extension; ..\..\..\..\..\include; ..\..\..\..\..\components\finsh; ..\..\..\..\..\components\drivers\smp; ..\..\..\..\..\libcpu\arm\common; ..\Libraries\drivers\config; .; ..\Libraries\MCXC444\MCXC444\drivers; board; ..\Libraries\MCXC444\MCXC444; ..\Libraries\CMSIS\Core\Include; ..\..\..\..\..\components\libc\posix\io\epoll; ..\..\..\..\..\components\drivers\include; ..\..\..\..\..\components\libc\posix\ipc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: template.out
  ILINK.IlinkIcfFile: board\linker_scripts\MCXC444_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG; CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; DEBUG; CPU_MCXC444VLH; __RTTHREAD__; __RT_IPC_SOURCE__; __RT_KERNEL_SOURCE__
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: main.c
  group Compiler
    ../../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../../../components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
  group DeviceDrivers
    ../../../../../components/drivers/core/: device.c
    ../../../../../components/drivers/hwtimer/: hwtimer.c
    ../../../../../components/drivers/i2c/: dev_i2c_bit_ops.c dev_i2c_core.c dev_i2c_dev.c
    ../../../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../../components/drivers/misc/: rt_drv_pwm.c
    ../../../../../components/drivers/pin/: dev_pin.c
    ../../../../../components/drivers/rtc/: dev_rtc.c
    ../../../../../components/drivers/serial/: dev_serial.c
    ../../../../../components/drivers/spi/: dev_spi.c dev_spi_core.c
  group Drivers
    board/MCUX_Config/board/: clock_config.c pin_mux.c
    board/: board.c
    ../Libraries/drivers/: drv_pin.c drv_uart.c
  group Finsh
    ../../../../../components/finsh/: msh_parse.c msh.c shell.c cmd.c
  group Kernel
    ../../../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
    ../../../../../src/klibc/: kerrno.c kstdio.c kstring.c
  group libcpu
    ../../../../../libcpu/arm/common/: div0.c showmem.c
    ../../../../../libcpu/arm/cortex-m0/: context_iar.S cpuport.c
  group Libraries
    ../Libraries/MCXC444/MCXC444/drivers/: fsl_dma.c fsl_uart.c fsl_i2c_dma.c fsl_sim.c fsl_lpuart_dma.c fsl_cop.c fsl_sai.c fsl_ftfx_flexnvm.c fsl_pit.c fsl_lpuart.c fsl_i2c.c fsl_uart_dma.c fsl_clock.c fsl_sai_dma.c fsl_adc16.c fsl_common.c fsl_smc.c fsl_common_arm.c fsl_rtc.c fsl_tpm.c fsl_cmp.c fsl_slcd.c fsl_pmc.c fsl_ftfx_controller.c fsl_spi.c fsl_dac.c fsl_gpio.c
    ../Libraries/MCXC444/MCXC444/iar/: startup_MCXC444.s
    ../Libraries/MCXC444/MCXC444/: system_MCXC444.c
