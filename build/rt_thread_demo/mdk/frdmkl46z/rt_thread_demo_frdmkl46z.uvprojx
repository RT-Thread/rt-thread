# Keil uVision project rt_thread_demo_frdmkl46z.uvprojx, settings and files
target rt_thread_demo_frdmkl46z Debug (ARM-ADS)
  device: MKL46Z256xxx4 Freescale
  cpu: CPUTYPE("Cortex-M0plus")
  output: rt_thread_demo.out
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: DEBUG, CPU_MKL46Z256VLL4, TWR_K64F120M
  c misc: --library_interface=armcc 
--library_type=standardlib 
--c99 
--diag_suppress=1296,186 
--diag_suppress=66
  c include: ../../../../bsp/freescale/platform/devices;../../../../bsp/freescale/platform/devices/MKL46Z4/include;../../../../bsp/freescale/platform/devices/MKL46Z4/startup;../../../../bsp/freescale/boards/frdmkl46z;../../../../bsp/freescale/common/sgtl5000;../../../../bsp/freescale/common/phyksz8041;../../../../bsp/freescale/platform/system/src/clock/MKL46Z4;../../../../bsp/freescale/rt_app;../../../../bsp/freescale/platform/drivers/inc;../../../../bsp/freescale/platform/hal/inc;../../../../bsp/freescale/rtos;../../../../bsp/freescale/platform/osa/inc;../../../../bsp/freescale/platform/CMSIS/Include;../../../../bsp/freescale/platform/system/inc;../../../../bsp/freescale/platform/utilities/inc;../../../../bsp/freescale/platform/utilities/src;../../../../components/drivers/include/drivers;../../../../components/drivers/include;../../../../bsp/freescale/driver_wrapper/inc;../../../../components/finsh;../../../../include
  asm misc: --cpreproc_opts '-DDEBUG'
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x6000
  scatter file: ../../../../bsp/freescale/platform/devices/MKL46Z4/linker/arm/MKL46Z256xxx4_flash.scf
  link misc: ../../../../lib/ksdk_platform_lib/KsdkPlatformLib/mdk/debug/libksdk_platform.lib 
--remove 
--predefine="-D__ram_vector_table__=1"
  group startup
    ../../../../bsp/freescale/platform/devices/MKL46Z4/startup/arm/: startup_MKL46Z4.s
    ../../../../bsp/freescale/platform/devices/MKL46Z4/startup/: system_MKL46Z4.c system_MKL46Z4.c system_MKL46Z4.c system_MKL46Z4.c system_MKL46Z4.c system_MKL46Z4.c system_MKL46Z4.c system_MKL46Z4.c system_MKL46Z4.c system_MKL46Z4.c system_MKL46Z4.c system_MKL46Z4.c
    ../../../../bsp/freescale/platform/devices/: startup.c startup.h startup.c startup.h startup.c startup.h startup.c startup.h startup.c startup.h startup.c startup.h startup.c startup.h startup.c startup.h startup.c startup.h startup.c startup.h startup.c startup.h startup.c startup.h
  group context
    ../../../../libcpu/arm/cortex-m0/: context_rvds.S
  group uart_wrapper
    ../../../../bsp/freescale/driver_wrapper/uart/: drv_uart.c fsl_uart_irq_rt.c
    ../../../../bsp/freescale/driver_wrapper/inc/: drv_uart.h
  group board
    ../../../../bsp/freescale/boards/frdmkl46z/: gpio_pins.c gpio_pins.h board.c board.h pin_mux.c pin_mux.h gpio_pins.c gpio_pins.h board.c board.h pin_mux.c pin_mux.h gpio_pins.c gpio_pins.h board.c board.h pin_mux.c pin_mux.h gpio_pins.c gpio_pins.h board.c board.h pin_mux.c pin_mux.h gpio_pins.c gpio_pins.h board.c board.h pin_mux.c pin_mux.h gpio_pins.c gpio_pins.h board.c board.h pin_mux.c pin_mux.h gpio_pins.c gpio_pins.h board.c board.h pin_mux.c pin_mux.h gpio_pins.c gpio_pins.h board.c board.h pin_mux.c pin_mux.h gpio_pins.c gpio_pins.h board.c board.h pin_mux.c pin_mux.h gpio_pins.c gpio_pins.h board.c board.h pin_mux.c pin_mux.h gpio_pins.c gpio_pins.h board.c board.h pin_mux.c pin_mux.h gpio_pins.c gpio_pins.h board.c board.h pin_mux.c pin_mux.h
  group utils
    ../../../../bsp/freescale/boards/frdmkl46z/: rtconfig.h
    ../../../../bsp/freescale/platform/utilities/src/: fsl_debug_console.c print_scan.c print_scan.h fsl_misc_utilities.c
    ../../../../bsp/freescale/platform/utilities/inc/: fsl_debug_console.h
  group general
    ../../../../components/drivers/src/: completion.c pipe.c portal.c ringbuffer.c workqueue.c dataqueue.c
  group finsh
    ../../../../components/finsh/: cmd.c finsh.h finsh_compiler.c finsh_error.c finsh_error.h finsh_heap.c finsh_heap.h finsh_init.c finsh_node.c finsh_node.h finsh_ops.c finsh_ops.h finsh_parser.c finsh_parser.h finsh_token.c finsh_token.h finsh_var.c finsh_var.h finsh_vm.c finsh_vm.h msh.c msh.h msh_cmd.c shell.c shell.h symbol.c
  group serial
    ../../../../components/drivers/serial/: serial.c
    ../../../../components/drivers/include/drivers/: serial.h
  group rt_core
    ../../../../src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c module.c object.c scheduler.c slab.c thread.c timer.c
  group app_src
    ../../../../bsp/freescale/rt_app/: application.c startup_app.c board_app.c board_app.h
  group cortex_m0
    ../../../../libcpu/arm/cortex-m0/: cpuport.c
  group arm
    ../../../../libcpu/arm/common/: backtrace.c div0.c showmem.c
target rt_thread_demo_frdmkl46z Release (ARM-ADS)
  device: MKL46Z256xxx4 Freescale
  cpu: CPUTYPE("Cortex-M0plus")
  output: rt_thread_demo.out
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: NDEBUG, CPU_MKL46Z256VLL4, TWR_K64F120M
  c misc: as above
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x2000
  memory RVCT10: RAM 0x20000000 size 0x6000
  scatter file: as above
  link misc: ../../../../lib/ksdk_platform_lib/KsdkPlatformLib/mdk/release/libksdk_platform.lib 
--remove 
--predefine="-D__ram_vector_table__=1"
