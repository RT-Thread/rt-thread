# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060020::V5.06 (build 20)::ARMCC)
  device: HC32L136K8TA HDSC
  pack: HDSC.HC32L136.1.0.1
  cpu: IRAM(0x20000000,0x2000) IROM(0x00000000,0x10000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: RT_USING_LIBC, USE_DDL_DRIVER, __RTTHREAD__, __DEBUG, __CLK_TCK=RT_TICK_PER_SECOND, RT_USING_ARMLIBC, __STDC_LIMIT_MACROS, HC32L136
  c misc: --diag_suppress=186,66
  c include: ..\..\components\drivers\include;..\..\components\drivers\include;Libraries\CMSIS\Include;Libraries\CMSIS\Device\HDSC\HC32L136\Include;..\..\components\drivers\include;..\..\libcpu\arm\cortex-m0;..\..\components\libc\posix\ipc;..\..\components\libc\compilers\common\include;..\..\components\libc\posix\io\eventfd;..\..\components\drivers\smp;Libraries\HC32L136_StdPeriph_Driver\inc;..\..\components\libc\posix\io\epoll;..\..\components\libc\posix\io\poll;..\..\components\libc\compilers\common\extension;..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\components\finsh;..\..\include;.;applications;drivers;board;..\..\components\drivers\include;..\..\libcpu\arm\common
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Applications
    applications/: main.c
  group Compiler
    ../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../components/drivers/core/: device.c
    ../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../components/drivers/pin/: dev_pin.c
    ../../components/drivers/serial/: dev_serial.c
  group Drivers
    board/: board.c
    drivers/: drv_gpio.c drv_usart.c
  group Finsh
    ../../components/finsh/: msh.c msh_parse.c shell.c cmd.c
  group HC32_StdPeriph
    Libraries/HC32L136_StdPeriph_Driver/src/: uart.c flash.c lpuart.c rtc.c ddl.c trim.c adc.c sysctrl.c timer3.c gpio.c
    Libraries/CMSIS/Device/HDSC/HC32L136/Source/: system_hc32l13x.c interrupts_hc32l136.c
    Libraries/CMSIS/Device/HDSC/HC32L136/Source/ARM/: startup_hc32l136.s
  group Kernel
    ../../src/: clock.c components.c cpu_up.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
    ../../src/klibc/: kerrno.c kstdio.c kstring.c
  group libcpu
    ../../libcpu/arm/common/: div0.c showmem.c
    ../../libcpu/arm/cortex-m0/: context_rvds.S cpuport.c
