# Keil uVision project project.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: V85XX Generic
  pack: Vango.V85XX.4.0.2
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: template
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_TARGET_DRIVER, V85xx, __CLK_TCK=RT_TICK_PER_SECOND, __STDC_LIMIT_MACROS, __RTTHREAD__, RT_USING_ARMLIBC, RT_USING_LIBC, USE_STDPERIPH_DRIVER
  c include: ..\..\..\components\libc\compilers\common\extension;..\..\..\include;..\..\..\components\drivers\phy;..\..\..\components\libc\posix\io\epoll;..\..\..\components\drivers\include;..\..\..\components\finsh;..\..\..\components\libc\posix\io\poll;..\..\..\components\drivers\include;libraries\CMSIS\Vango\V85xx\Include;..\..\..\components\libc\compilers\common\extension\fcntl\octal;libraries\CMSIS;..\..\..\components\drivers\smp_call;..\..\..\components\dfs\dfs_v1\filesystems\devfs;..\..\..\components\drivers\include;..\..\..\libcpu\arm\common;..\..\..\components\drivers\include;..\..\..\components\drivers\include;applications;.;..\..\..\components\dfs\dfs_v1\include;..\..\..\components\libc\posix\ipc;libraries\VangoV85xx_standard_peripheral\Include;..\..\..\components\net\utest;..\..\..\components\libc\compilers\common\include;..\..\..\components\libc\posix\io\eventfd;drivers;..\..\..\libcpu\arm\cortex-m0;..\..\..\components\drivers\include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Applications
    applications/: main.c
  group CPU
    ../../../libcpu/arm/common/: div0.c showmem.c
    ../../../libcpu/arm/cortex-m0/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/pin/: dev_pin.c
    ../../../components/drivers/serial/: dev_serial.c
  group Drivers
    drivers/: board.c drv_usart.c drv_gpio.c
  group Filesystem
    ../../../components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    ../../../components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c msh_file.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group Libc
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
  group Vango_Lib
    libraries/VangoV85xx_standard_peripheral/Source/: lib_adc.c lib_adc_tiny.c lib_ana.c lib_clk.c lib_comp.c lib_crypt.c lib_dma.c lib_flash.c lib_gpio.c lib_i2c.c lib_iso7816.c lib_lcd.c lib_misc.c lib_pmu.c lib_pwm.c lib_rtc.c lib_spi.c lib_tmr.c lib_u32k.c lib_uart.c lib_version.c lib_wdt.c
    libraries/CMSIS/Vango/V85xx/Source/: system_target.c lib_CodeRAM.c lib_cortex.c lib_LoadNVR.c
    libraries/CMSIS/Vango/V85xx/Source/Keil5/: startup_target.S
