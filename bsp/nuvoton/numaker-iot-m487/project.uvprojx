# Keil uVision project project.uvprojx, settings and files
target rtthread-m480 (ARM-ADS)
  device: M487JIDAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.13
  cpu: IRAM(0x20000000,0x28000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: rtthread +hex
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "$L@L.axf"
  c flags: Optim=3 v6Lang=1 v6LangP=1
  c define: RT_USING_LIBC, __RTTHREAD__, __STDC_LIMIT_MACROS, RT_USING_ARM_LIBC, __CLK_TCK=RT_TICK_PER_SECOND
  c misc: --c99
  c include: applications;.;..\..\..\components\net\at\include;..\..\..\components\net\at\at_socket;packages\at_device-latest\inc;packages\at_device-latest\class\esp8266;..\libraries\m480\CMSIS\Include;..\..\..\components\libc\compilers\common\include;..\..\..\components\libc\compilers\common\extension;..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\libcpu\arm\common;..\..\..\libcpu\arm\cortex-m4;..\..\..\components\drivers\audio;..\..\..\components\drivers\include;..\..\..\components\drivers\hwcrypto;.;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\spi;..\..\..\components\drivers\include;..\..\..\components\drivers\spi\sfud\inc;..\..\..\components\drivers\include;board;board\NuClockConfig;board\NuPinConfig;..\libraries\m480\Device\Nuvoton\M480\Include;..\libraries\m480\rtt_port;..\..\..\components\fal\inc;..\..\..\components\dfs\include;..\..\..\components\dfs\filesystems\devfs;..\..\..\components\dfs\filesystems\elmfat;..\..\..\components\finsh;.;..\..\..\include;..\libraries\m480\StdDriver\inc;..\libraries\m480\USBHostLib\inc;..\libraries\nu_packages\BMX055;..\libraries\nu_packages\BMX055\libraries\BMA2x2_driver;..\libraries\nu_packages\BMX055\libraries\BMG160_driver;..\libraries\nu_packages\BMX055\libraries\BMM050_driver;..\libraries\nu_packages\Demo;..\libraries\nu_packages\AudioCodec;..\libraries\nu_packages\TPC;..\libraries\nu_packages\NuUtils\inc;..\..\..\components\libc\posix\io\poll;..\..\..\components\libc\posix\io\stdio;..\..\..\components\libc\posix\ipc;..\..\..\components\drivers\usb\usbdevice;..\..\..\components\drivers\usb\usbhost;..\..\..\components\drivers\usb\usbhost\class;..\..\..\components\drivers\usb\usbhost\core;..\..\..\components\drivers\usb\usbhost\include;..\..\..\components\drivers\include;..\..\..\components\net\netdev\include;..\..\..\components\net\sal\include;..\..\..\components\net\sal\include\socket;..\..\..\components\net\sal\impl;..\..\..\components\net\sal\include\dfs_net;..\..\..\components\net\sal\include\socket\sys_socket;..\..\..\components\drivers\sensors;..\..\..\components\drivers\include;..\..\..\components\utilities\utest
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  scatter file: .\linking_scripts\m480_flash.sct
  group Applications
    applications/: main.c mnt.c
  group AT
    ../../../components/net/at/src/: at_cli.c at_client.c at_utils.c
    ../../../components/net/at/at_socket/: at_socket.c
  group at_device
    packages/at_device-latest/src/: at_device.c
    packages/at_device-latest/class/esp8266/: at_device_esp8266.c at_socket_esp8266.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdio.c cstdlib.c cstring.c ctime.c cwchar.c
  group CPU
    ../../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../../components/drivers/audio/: audio.c audio_pipe.c
    ../../../components/drivers/can/: can.c
    ../../../components/drivers/hwcrypto/: hw_crc.c hw_hash.c hw_rng.c hw_symmetric.c hwcrypto.c
    ../../../components/drivers/hwtimer/: hwtimer.c
    ../../../components/drivers/i2c/: i2c-bit-ops.c i2c_core.c i2c_dev.c
    ../../../components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/misc/: adc.c pin.c rt_drv_pwm.c
    ../../../components/drivers/pm/: lptimer.c pm.c
    ../../../components/drivers/rtc/: rtc.c
    ../../../components/drivers/sdio/: block_dev.c mmc.c mmcsd_core.c sd.c sdio.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/spi/: qspi_core.c spi_core.c spi_dev.c spi_flash_sfud.c
    ../../../components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    ../../../components/drivers/watchdog/: watchdog.c
  group Drivers
    ../libraries/m480/Device/Nuvoton/M480/Source/ARM/: startup_M480.s
    ../libraries/m480/Device/Nuvoton/M480/Source/: system_M480.c
    board/NuClockConfig/: nutool_modclkcfg.c
    board/NuPinConfig/: nutool_pincfg.c
    board/: board_dev.c
    ../libraries/m480/rtt_port/: drv_bpwm.c drv_bpwm_capture.c drv_can.c drv_clk.c drv_common.c drv_crc.c drv_crypto.c drv_eadc.c drv_ebi.c drv_ecap.c drv_emac.c drv_epwm.c drv_epwm_capture.c drv_fmc.c drv_gpio.c drv_hsotg.c drv_hsusbd.c drv_i2c.c drv_i2s.c drv_pdma.c drv_qei.c drv_qspi.c drv_rtc.c drv_scuart.c drv_sdh.c drv_sdio.c drv_softi2c.c drv_spi.c drv_spii2s.c drv_timer.c drv_timer_capture.c drv_tpwm.c drv_trng.c drv_uart.c drv_ui2c.c drv_usbd.c drv_usbhost.c drv_uspi.c drv_uuart.c drv_wdt.c
  group Fal
    ../../../components/fal/src/: fal_rtt.c fal_flash.c fal.c fal_partition.c
  group Filesystem
    ../../../components/dfs/filesystems/devfs/: devfs.c
    ../../../components/dfs/filesystems/elmfat/: dfs_elm.c ff.c ffunicode.c
    ../../../components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c msh_file.c
  group Kernel
    ../../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group Libraries
    ../libraries/m480/StdDriver/src/: nu_pdma.c nu_clk.c nu_acmp.c nu_ebi.c nu_trng.c nu_usci_i2c.c nu_ccap.c nu_usci_uart.c nu_ecap.c nu_dac.c nu_spim.c nu_hsusbd.c nu_usbd.c nu_qei.c nu_epwm.c nu_crypto.c nu_scuart.c nu_sdh.c nu_sys.c nu_usci_spi.c nu_bpwm.c nu_fmc.c nu_wwdt.c nu_qspi.c nu_i2s.c nu_gpio.c nu_emac.c nu_i2c.c nu_wdt.c nu_can.c nu_uart.c nu_spi.c nu_timer.c nu_eadc.c nu_rtc.c nu_sc.c nu_timer_pwm.c nu_crc.c
  group m480_usbhostlib
    ../libraries/m480/USBHostLib/src/: mem_alloc.c ehci.c ehci_iso.c ohci.c usb_core.c
  group nu_pkgs_bmx055
    ../libraries/nu_packages/BMX055/libraries/BMG160_driver/: bmg160.c
    ../libraries/nu_packages/BMX055/libraries/BMA2x2_driver/: bma2x2.c
    ../libraries/nu_packages/BMX055/: sensor_bmx055.c
    ../libraries/nu_packages/BMX055/libraries/BMM050_driver/: bmm050.c
  group nu_pkgs_demo
    ../libraries/nu_packages/Demo/: usbd_cdc_vcom_echo.c slcd_show_tick.c usbd_hid_dance_mouse.c
  group nu_pkgs_nau88l25
    ../libraries/nu_packages/AudioCodec/: audio_test.c acodec_nau88l25.c
  group POSIX
    ../../../components/libc/posix/io/poll/: poll.c select.c
  group rt_usbd
    ../../../components/drivers/usb/usbdevice/core/: usbdevice_core.c usbdevice.c
    ../../../components/drivers/usb/usbdevice/class/: hid.c
  group rt_usbh
    ../../../components/drivers/usb/usbhost/class/: udisk.c mass.c
    ../../../components/drivers/usb/usbhost/core/: hub.c usbhost.c usbhost_core.c driver.c
  group SAL
    ../../../components/net/netdev/src/: netdev.c netdev_ipaddr.c
    ../../../components/net/sal/dfs_net/: dfs_net.c
    ../../../components/net/sal/impl/: af_inet_at.c
    ../../../components/net/sal/socket/: net_netdb.c net_sockets.c
    ../../../components/net/sal/src/: sal_socket.c
  group Sensors
    ../../../components/drivers/sensors/: sensor_cmd.c sensor.c
  group UTest
    ../../../components/utilities/utest/: utest.c
software components: CMSIS:CORE 5.1.2
