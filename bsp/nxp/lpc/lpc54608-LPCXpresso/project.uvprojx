# Keil uVision project project.uvprojx, settings and files
target rtthread-lpc546xx (ARM-ADS)
  device: LPC54608J512ET180:M4 NXP
  pack: Keil.LPC54000_DFP.2.5.0
  cpu: IROM(0x00000000,0x00080000) IRAM(0x20000000,0x00028000) IRAM2(0x04000000,0x00008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rtthread-lpc546xx
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: RT_USING_ARMLIBC, CORE_M4, CPU_LPC54608J512ET180=1, __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND, SDK_DEBUGCONSOLE=0, RT_USING_LIBC, __STDC_LIMIT_MACROS, CPU_LPC54608
  c misc: --library_interface=armcc --library_type=standardlib --diag_suppress=66,1296,186
  c include: SDK_2.2_LPCXpresso54608\devices\LPC54608\drivers;..\..\..\..\components\libc\posix\tls;..\..\..\..\components\drivers\smp_call;..\..\..\..\components\drivers\include;..\..\..\..\components\libc\compilers\common\include;..\..\..\..\components\libc\cplusplus;..\..\..\..\components\drivers\phy;..\..\..\..\components\drivers\include;..\..\..\..\components\dfs\dfs_v1\include;..\..\..\..\components\net\netdev\include;..\..\..\..\components\net\lwip\lwip-2.0.3\src\include;..\..\..\..\include;..\..\..\..\components\libc\posix\pthreads;..\..\..\..\components\net\sal\include\dfs_net;..\..\..\..\libcpu\arm\cortex-m4;..\..\..\..\components\dfs\dfs_v1\filesystems\elmfat;..\..\..\..\components\net\sal\include\socket\sys_socket;..\..\..\..\components\libc\posix\ipc;..\..\..\..\components\drivers\sdio\sdhci\include;..\..\..\..\components\libc\posix\delay;.;..\..\..\..\components\libc\compilers\common\extension;..\..\..\..\components\net\sal\include\socket;..\..\..\..\components\drivers\ktime\inc;..\..\..\..\components\drivers\include;..\..\..\..\components\libc\posix\io\epoll;drivers;..\..\..\..\components\drivers\spi;..\..\..\..\components\drivers\include;..\..\..\..\components\net\lwip\port;..\..\..\..\components\libc\posix\io\eventfd;SDK_2.2_LPCXpresso54608\devices\LPC54608;..\..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\..\components\drivers\include;..\..\..\..\components\drivers\ktime;..\..\..\..\components\net\sal\impl;..\..\..\..\components\drivers\include;..\..\..\..\components\drivers\include;SDK_2.2_LPCXpresso54608\devices\LPC54608\utilities;..\..\..\..\components\net\lwip\lwip-2.0.3\src\include\netif;SDK_2.2_LPCXpresso54608\sdmmc_2.1.2\inc;applications;SDK_2.2_LPCXpresso54608\sdmmc_2.1.2\src;..\..\..\..\components\drivers\include;..\..\..\..\components\libc\posix\io\poll;..\..\..\..\components\drivers\include;..\..\..\..\libcpu\arm\common;..\..\..\..\components\drivers\include;..\..\..\..\components\net\lwip\lwip-2.0.3\src\include\ipv4;..\..\..\..\components\finsh;..\..\..\..\components\net\sal\include;..\..\..\..\components\dfs\dfs_v1\filesystems\devfs;SDK_2.2_LPCXpresso54608\CMSIS\Include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x28000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: .\LPC54608J512_flash.scf
  group Applications
    applications/: main.c mnt.c
  group CMSIS
    SDK_2.2_LPCXpresso54608/devices/LPC54608/arm/: startup_LPC54608.s keil_lib_power.lib
    SDK_2.2_LPCXpresso54608/devices/LPC54608/: system_LPC54608.c
  group Compiler
    ../../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group CPP
    ../../../../components/libc/cplusplus/: cxx_crt_init.c cxx_crt.cpp
  group DeviceDrivers
    ../../../../components/drivers/core/: device.c
    ../../../../components/drivers/i2c/: dev_i2c_bit_ops.c dev_i2c_core.c dev_i2c_dev.c
    ../../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../components/drivers/mtd/: mtd_nand.c
    ../../../../components/drivers/pin/: dev_pin.c
    ../../../../components/drivers/rtc/: dev_rtc.c
    ../../../../components/drivers/sdio/: dev_block.c dev_mmc.c dev_mmcsd_core.c dev_sd.c dev_sdio.c
    ../../../../components/drivers/serial/: dev_serial.c
    ../../../../components/drivers/spi/: dev_spi.c dev_spi_core.c
  group Drivers
    drivers/: drv_i2c.c board.c drv_uart.c drt_mpu.c drv_sdram.c fsl_phy.c drv_emac.c drv_ft5406.c drv_sram.c clock_config.c drv_lcd.c drv_sd.c
  group Filesystem
    ../../../../components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    ../../../../components/dfs/dfs_v1/filesystems/elmfat/: dfs_elm.c ff.c ffunicode.c
    ../../../../components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    ../../../../components/finsh/: msh_parse.c msh.c shell.c msh_file.c cmd.c
  group Kernel
    ../../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    ../../../../src/klibc/: rt_vsscanf.c kerrno.c kstdio.c rt_vsnprintf_tiny.c kstring.c
  group ktime
    ../../../../components/drivers/ktime/src/: cputimer.c boottime.c hrtimer.c
  group libcpu
    ../../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group Libraries
    SDK_2.2_LPCXpresso54608/devices/LPC54608/drivers/: fsl_adc.c fsl_clock.c fsl_common.c fsl_crc.c fsl_ctimer.c fsl_dma.c fsl_dmic.c fsl_dmic_dma.c fsl_eeprom.c fsl_emc.c fsl_enet.c fsl_flashiap.c fsl_flexcomm.c fsl_fmc.c fsl_fmeas.c fsl_gint.c fsl_gpio.c fsl_i2c.c fsl_i2c_dma.c fsl_i2s.c fsl_i2s_dma.c fsl_inputmux.c fsl_lcdc.c fsl_mcan.c fsl_mrt.c fsl_pint.c fsl_power.c fsl_reset.c fsl_rit.c fsl_rtc.c fsl_sctimer.c fsl_sdif.c fsl_spi.c fsl_spi_dma.c fsl_spifi.c fsl_spifi_dma.c fsl_usart.c fsl_usart_dma.c fsl_utick.c fsl_wwdt.c
    SDK_2.2_LPCXpresso54608/sdmmc_2.1.2/src/: fsl_host.c fsl_sd.c fsl_sd_event.c fsl_sdmmc.c
  group lwIP
    ../../../../components/net/lwip/lwip-2.0.3/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../../components/net/lwip/lwip-2.0.3/src/apps/ping/: ping.c
    ../../../../components/net/lwip/lwip-2.0.3/src/core/: def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../../components/net/lwip/lwip-2.0.3/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../../components/net/lwip/lwip-2.0.3/src/netif/: ethernet.c lowpan6.c
    ../../../../components/net/lwip/port/: ethernetif.c sys_arch.c
  group POSIX
    ../../../../components/libc/posix/delay/: delay.c
    ../../../../components/libc/posix/io/poll/: poll.c select.c
    ../../../../components/libc/posix/pthreads/: pthread.c pthread_attr.c pthread_barrier.c pthread_cond.c pthread_mutex.c pthread_rwlock.c pthread_spin.c pthread_tls.c sched.c
    ../../../../components/libc/posix/tls/: emutls.c
  group SAL
    ../../../../components/net/netdev/src/: netdev.c netdev_ipaddr.c
    ../../../../components/net/sal/dfs_net/: dfs_net.c
    ../../../../components/net/sal/impl/: af_inet_lwip.c
    ../../../../components/net/sal/socket/: net_netdb.c net_sockets.c
    ../../../../components/net/sal/src/: sal_socket.c
