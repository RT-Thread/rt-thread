# Keil uVision project template.uvprojx, settings and files
target hc32f480 (ARM-ADS)
  device: HC32F480RGTB HDSC
  pack: HDSC.HC32F480.1.0.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") CLOCK(12000000) ESEL ELITTLE
  output: hc32f480 +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=4 uC99=1
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff8000 size 0x7fff
  memory RVCT10: RAM 0x20000000 size 0x1ffff
