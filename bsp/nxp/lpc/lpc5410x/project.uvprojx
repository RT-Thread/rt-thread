# Keil uVision project project.uvprojx, settings and files
target rtthread-lpc5410x (ARM-ADS)
  device: LPC54102:M4 NXP
  cpu: IROM(0x00000000,0x80000) IRAM(0x02000000,0x10000) IRAM2(0x02010000,0x08000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rtthread-lpc5410x +hex
  c flags: Optim=1 wLevel=2
  c define: __RTTHREAD__, __STDC_LIMIT_MACROS, CORE_M4, RT_USING_ARMLIBC, __CLK_TCK=RT_TICK_PER_SECOND, RT_USING_LIBC
  c include: ..\..\..\..\components\dfs\dfs_v1\include;..\..\..\..\components\dfs\dfs_v1\filesystems\elmfat;..\..\..\..\components\libc\posix\ipc;Libraries\lpc_chip\chip_common;..\..\..\..\components\libc\compilers\common\include;Libraries\lpc_chip\chip_5410x;..\..\..\..\include;..\..\..\..\components\drivers\include;..\..\..\..\components\drivers\include;..\..\..\..\components\dfs\dfs_v1\filesystems\devfs;..\..\..\..\components\drivers\include;..\..\..\..\components\drivers\include;..\..\..\..\components\drivers\phy;..\..\..\..\components\drivers\smp_call;..\..\..\..\libcpu\arm\common;.;..\..\..\..\libcpu\arm\cortex-m4;..\..\..\..\components\libc\posix\io\eventfd;..\..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\..\components\libc\posix\io\epoll;drivers;..\..\..\..\components\libc\posix\io\poll;..\..\..\..\components\drivers\include;Libraries\lpc_chip\chip_5410x\config;..\..\..\..\components\finsh;applications;..\..\..\..\components\libc\compilers\common\extension;Libraries\CMSIS\Include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x2000000 size 0x10000
  memory RVCT10: RAM 0x2010000 size 0x8000
  group Applications
    applications/: startup.c demo_thread.c application.c board.c
  group CMSIS
    Libraries/Device/startup/: keil_startup_lpc5410x.s sysinit.c
  group Compiler
    ../../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../../components/drivers/core/: device.c
    ../../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../components/drivers/pin/: dev_pin.c
    ../../../../components/drivers/serial/: dev_serial.c
  group Drivers
    drivers/: drv_led.c drv_uart.c
  group Filesystem
    ../../../../components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    ../../../../components/dfs/dfs_v1/filesystems/elmfat/: dfs_elm.c ff.c ffunicode.c
    ../../../../components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    ../../../../components/finsh/: msh_parse.c msh_file.c cmd.c shell.c msh.c
  group Kernel
    ../../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    ../../../../src/klibc/: kerrno.c rt_vsscanf.c rt_vsnprintf_tiny.c kstring.c kstdio.c
  group libcpu
    ../../../../libcpu/arm/common/: div0.c showmem.c
    ../../../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group Libraries
    Libraries/lpc_chip/chip_5410x/: utick_5410x.c chip_5410x.c hw_adc.c hw_i2cmd.c syscon_5410x.c pinint_5410x.c hw_spisd_rom_api.c hw_dmaaltd.c hw_i2cmond.c romapi_spim.c clock_5410x.c romapi_i2cmon.c sysinit_5410x.c romapi_i2cm.c stopwatch_5410x.c romapi_uart.c hw_i2cmond_rom_api.c romapi_adc.c crc_5410x.c ritimer_5410x.c rtc_5410x.c hw_i2csd_rom_api.c hw_i2csd.c gpiogroup_5410x.c romapi_dma.c hw_dmaaltd_rom_api.c wwdt_5410x.c pll_5410x.c sct_5410x.c romapi_i2cs.c hw_spimd.c hw_uart.c hw_i2cmd_rom_api.c iocon_5410x.c timer_5410x.c sct_pwm_5410x.c romapi_spis.c hw_spimd_rom_api.c fifo_5410x.c hw_spisd.c gpio_5410x.c
    Libraries/lpc_chip/chip_common/: ring_buffer.c fpu_init.c iap.c rtc_ut.c
    Libraries/lpc_chip/chip_5410x/power_lib/keil/: lib_power.lib
