# Keil uVision project template.uvprojx, settings and files
target Target 1 (6090000::V6.9::.\ARMCLANG)
  device: XMC7100D-F144K4160:Cortex-M7-0 Infineon
  pack: Infineon.CAT1C_DFP.1.0.0
  cpu: IRAM(0x28000000,0xC0000) IROM(0x10000000,0x410000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: rtthread +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=3
  memory RVCT4: ROM 0x10000000 size 0x410000
  memory RVCT9: RAM 0x28000000 size 0xc0000
  scatter file: .\board\linker_scripts\link.sct
