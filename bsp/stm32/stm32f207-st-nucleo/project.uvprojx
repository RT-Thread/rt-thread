# Keil uVision project project.uvprojx, settings and files
target rtthread (ARM-ADS)
  device: STM32F207ZGTx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.7.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32F207xx, __CLK_TCK=RT_TICK_PER_SECOND, __STDC_LIMIT_MACROS, RT_USING_ARMLIBC, __RTTHREAD__, RT_USING_LIBC
  c include: ..\libraries\HAL_Drivers\drivers;..\..\..\libcpu\arm\common;..\..\..\components\drivers\smp_call;.;..\..\..\include;..\libraries\HAL_Drivers\drivers\config;..\libraries\STM32F2xx_HAL\CMSIS\Device\ST\STM32F2xx\Include;..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\libcpu\arm\cortex-m3;..\..\..\components\libc\compilers\common\include;..\..\..\components\drivers\include;..\..\..\components\libc\compilers\common\extension;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\libc\posix\io\poll;..\libraries\STM32F2xx_HAL\STM32F2xx_HAL_Driver\Inc;..\..\..\components\finsh;..\..\..\components\drivers\include;applications;..\libraries\HAL_Drivers;..\..\..\components\drivers\phy;board;..\libraries\HAL_Drivers\CMSIS\Include;..\..\..\components\libc\posix\io\eventfd;..\..\..\components\libc\posix\ipc;..\..\..\components\libc\posix\io\epoll;board\CubeMX_Config\Core\Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/pin/: dev_pin.c
    ../../../components/drivers/serial/: dev_serial.c
  group Drivers
    ../libraries/HAL_Drivers/drivers/: drv_gpio.c drv_usart.c
    ../libraries/HAL_Drivers/: drv_common.c
    ../libraries/STM32F2xx_HAL/CMSIS/Device/ST/STM32F2xx/Source/Templates/arm/: startup_stm32f207xx.s
    board/CubeMX_Config/Core/Src/: stm32f2xx_hal_msp.c
    board/: board.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c cmd.c msh_parse.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    ../../../src/klibc/: rt_vsnprintf_tiny.c kerrno.c kstring.c kstdio.c rt_vsscanf.c
  group libcpu
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m3/: context_rvds.S cpuport.c
  group Libraries
    ../libraries/STM32F2xx_HAL/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal_crc.c stm32f2xx_hal.c stm32f2xx_hal_usart.c stm32f2xx_hal_uart.c stm32f2xx_hal_cortex.c stm32f2xx_hal_sram.c stm32f2xx_hal_pwr.c stm32f2xx_hal_dma.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_gpio.c stm32f2xx_hal_rcc.c
    ../libraries/STM32F2xx_HAL/CMSIS/Device/ST/STM32F2xx/Source/Templates/: system_stm32f2xx.c
