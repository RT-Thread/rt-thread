# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1052xxx6A NXP MIMXRT1052xxx6A
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 0
  ICCARM.CCDefines: CPU_MIMXRT1052DVL6A; CPU_MIMXRT1052DVL6A
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ..\..\include; device\MIMXRT1052; ..\..\libcpu\arm\cortex-m7; .; applications; board; ..\..\components\drivers\include; device; ..\..\libcpu\arm\common; ..\..\components\finsh; ..\..\components\dfs\filesystems\elmfat; ..\..\include; device\MIMXRT1052; ..\..\libcpu\arm\cortex-m7; .; applications; board; ..\..\components\drivers\include; device; ..\..\libcpu\arm\common; ..\..\components\dfs\filesystems\devfs; ..\..\components\finsh; ..\..\components\dfs\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: project.srec
  ILINK.IlinkOutputFile: template.out
  ILINK.IlinkIcfFile: rt1050_ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CPU_MIMXRT1052DVL6A; CPU_MIMXRT1052DVL6A
  ICCARM.CCOptLevel: 3
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: device\iar\MIMXRT1052xxxxx_flexspi_nor.icf
  group Applications
    applications/: application.c startup.c
  group Board
    board/: board.c clock_config.c drv_uart.c led.c pin_mux.c
  group CORTEX-M7
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../libcpu/arm/cortex-m7/: context_iar.S cpuport.c
  group Device
    device/MIMXRT1052/: fsl_adc.c fsl_adc_etc.c fsl_aipstz.c fsl_aoi.c fsl_bee.c fsl_cache.c fsl_clock.c fsl_cmp.c fsl_common.c fsl_csi.c fsl_dcdc.c fsl_dcp.c fsl_dmamux.c fsl_edma.c fsl_elcdif.c fsl_enc.c fsl_enet.c fsl_ewm.c fsl_flexcan.c fsl_flexio.c fsl_flexio_i2c_master.c fsl_flexio_i2s.c fsl_flexio_i2s_edma.c fsl_flexio_spi.c fsl_flexio_spi_edma.c fsl_flexio_uart.c fsl_flexio_uart_edma.c fsl_flexram.c fsl_flexspi.c fsl_gpc.c fsl_gpio.c fsl_gpt.c fsl_kpp.c fsl_lpi2c.c fsl_lpi2c_edma.c fsl_lpspi.c fsl_lpspi_edma.c fsl_lpuart.c fsl_lpuart_edma.c fsl_pit.c fsl_pmu.c fsl_pwm.c fsl_pxp.c fsl_qtmr.c fsl_rtwdog.c fsl_sai.c fsl_sai_edma.c fsl_semc.c fsl_snvs_hp.c fsl_snvs_lp.c fsl_spdif.c fsl_spdif_edma.c fsl_src.c fsl_trng.c fsl_tsc.c fsl_usdhc.c fsl_wdog.c fsl_xbara.c fsl_xbarb.c
    device/iar/: startup_MIMXRT1052.s
    device/: system_MIMXRT1052.c
  group DeviceDrivers
    ../../components/drivers/sdio/: block_dev.c mmc.c mmcsd_core.c sd.c sdio.c
    ../../components/drivers/src/: completion.c dataqueue.c pipe.c ringbuffer.c waitqueue.c workqueue.c
    ../../components/drivers/serial/: serial.c
  group Filesystem
    ../../components/dfs/filesystems/devfs/: devfs.c
    ../../components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
    ../../components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
  group finsh
    ../../components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c msh.c msh_cmd.c msh_file.c shell.c symbol.c
  group Kernel
    ../../src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c object.c scheduler.c signal.c thread.c timer.c
