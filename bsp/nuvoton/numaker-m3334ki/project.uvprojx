# Keil uVision project project.uvprojx, settings and files
target rtthread-m3331 (6220000::V6.22::ARMCLANG)
  device: M3334KIGAE Nuvoton
  pack: Nuvoton.NuMicroM33_DFP.1.0.2
  cpu: IRAM(0x20000000,0x60000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ESEL ELITTLE
  output: rtthread +hex
  AfterMake: fromelf --bin ".\build\keil5\\@L.axf" --output ".\build\keil5\\@L.bin"
  AfterMake: fromelf --text -c ".\build\keil5\\@L.axf" --output ".\build\keil5\\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=5 v6LangP=3
  c define: __CLK_TCK=RT_TICK_PER_SECOND, RT_USING_ARMLIBC, RT_USING_LIBC, __RTTHREAD__, __STDC_LIMIT_MACROS
  c include: ..\..\..\components\net\utest;..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\examples\utest\testcases\lwp;..\..\..\libcpu\arm\common;..\..\..\components\libc\posix\io\epoll;board\NuPinConfig;test\wdt;..\libraries\nu_packages\TPC;..\..\..\components\libc\compilers\common\extension;..\..\..\components\drivers\include;..\..\..\components\dfs\dfs_v1\filesystems\devfs;..\..\..\components\dfs\utest;..\..\..\components\drivers\include;packages\nuvoton-series-latest\CMSIS\Core\Include;test\rtc;..\..\..\components\drivers\include;..\..\..\components\drivers\smp_call\utest;..\..\..\components\drivers\core\utest;..\..\..\components\libc\posix\io\eventfd;..\..\..\libcpu\arm\cortex-m33;..\..\..\components\libc\posix\io\poll;packages\nuvoton-series-latest\M3331\Device\Nuvoton\m3331\Include;test\template;..\..\..\components\dfs\dfs_v1\include;..\..\..\components\drivers\include;..\..\..\include;..\..\..\components\utilities\utest;..\..\..\examples\utest\testcases\mm;test\hwtimer;..\..\..\examples\utest\testcases\tmpfs;..\..\..\components\dfs\dfs_v1\filesystems\elmfat;..\libraries\nu_packages\NuUtils\inc;test\uart;packages\nuvoton-series-latest\M3331\StdDriver\inc;board\NuClockConfig;test\canfd;..\..\..\components\drivers\ipc\utest;test\pdma;board;..\..\..\components\finsh;..\..\..\components\libc\compilers\common\include;test\crc;..\..\..\components\drivers\serial\utest;..\libraries\m3331\rtt_port;..\..\..\src\utest\smp;..\..\..\components\utilities\ulog;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\phy;..\..\..\components\drivers\smp_call;.;test\clk;applications;..\..\..\components\libc\posix\ipc;..\..\..\src\utest;..\..\..\components\fal\inc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x60000
  scatter file: .\linking_scripts\M3331.sct
  group Applications
    applications/: main.c mnt.c pm_test.c
  group board
    board/NuPinConfig/: nutool_pincfg.c
    board/: NTFUN_board_dev.c NUTFT_board_dev.c custom_loader.c nutool_modclkcfg.c
  group CPU
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m33/: context_rvds.S cpuport.c syscall_rvds.S trustzone.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/pin/: dev_pin.c
    ../../../components/drivers/serial/: dev_serial.c
  group Drivers
    packages/nuvoton-series-latest/M3331/Device/Nuvoton/m3331/Source/: startup_m3331.c system_m3331.c
    ../libraries/m3331/rtt_port/: drv_bpwm.c drv_bpwm_capture.c drv_canfd.c drv_clk.c drv_common.c drv_crc.c drv_crypto.c drv_eadc.c drv_ebi.c drv_ecap.c drv_epwm.c drv_epwm_capture.c drv_eqei.c drv_fmc.c drv_gpio.c drv_i2c.c drv_i2s.c drv_llsi.c drv_pdma.c drv_qspi.c drv_rtc.c drv_sdio.c drv_softi2c.c drv_spi.c drv_spii2s.c drv_timer.c drv_tpwm.c drv_uart.c drv_ui2c.c drv_uspi.c drv_uuart.c drv_wdt.c
  group Fal
    ../../../components/fal/src/: fal.c fal_flash.c fal_partition.c fal_rtt.c
  group Filesystem
    ../../../components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    ../../../components/dfs/dfs_v1/filesystems/elmfat/: dfs_elm.c ff.c ffunicode.c
    ../../../components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c msh_file.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler_comm.c scheduler_up.c signal.c thread.c timer.c
  group Libc
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
  group Libraries
    packages/nuvoton-series-latest/M3331/StdDriver/src/: nu_acmp.c nu_bpwm.c nu_canfd.c nu_clk.c nu_crc.c nu_eadc.c nu_ebi.c nu_ecap.c nu_ellsi.c nu_epwm.c nu_eqei.c nu_fmc.c nu_gpio.c nu_i2c.c nu_i2s.c nu_i3c.c nu_llsi.c nu_pdma.c nu_qspi.c nu_rtc.c nu_sdh.c nu_spi.c nu_sys.c nu_timer.c nu_timer_pwm.c nu_uart.c nu_usci_i2c.c nu_usci_spi.c nu_usci_uart.c nu_wdt.c nu_wwdt.c
  group NuUTestCases
    test/canfd/: utest_canfd.c
    test/clk/: utest_clk.c
    test/crc/: utest_crypto.c
    test/hwtimer/: utest_hwtimer.c
    test/pdma/: utest_pdma.c
    test/rtc/: utest_rtc.c
    test/template/: utest_template.c
    test/uart/: utest_uart.c
    test/wdt/: utest_wdt.c
  group utc_UTest
    ../../../components/utilities/utest/utest/: TC_uassert.c
  group UTest
    ../../../components/utilities/utest/: utest.c
  group Utilities
    ../../../components/utilities/ulog/: ulog.c
    ../../../components/utilities/ulog/backend/: console_be.c
