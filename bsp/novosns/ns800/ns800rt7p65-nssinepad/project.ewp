# IAR project project.ewp, settings and files
configuration rtthread (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; __RTTHREAD__; __RT_IPC_SOURCE__; __RT_KERNEL_SOURCE__
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\libraries\HAL_Drivers\drivers\config; ..\libraries\HAL_Drivers\drivers; ..\..\..\components\libc\compilers\common\extension\fcntl\octal; ..\..\..\components\libc\posix\ipc; ..\..\..\components\libc\posix\io\eventfd; ..\libraries\HAL_Drivers; .; packages\novosns-series\NS800RT7XXX\Device\Inc; packages\novosns-series\NS800RT7XXX\StdDriver\Inc; packages\novosns-series\NS800RT7XXX\StdDriver\Inc\ti; ..\..\..\components\libc\posix\io\epoll; ..\..\..\components\drivers\include; ..\..\..\components\libc\posix\io\poll; ..\..\..\include; ..\..\..\components\libc\compilers\common\extension; ..\..\..\libcpu\arm\cortex-m7; ..\..\..\components\drivers\smp_call; ..\..\..\components\finsh; ..\..\..\components\libc\compilers\common\include; applications; ..\..\..\libcpu\arm\common; ..\..\..\components\drivers\phy; board
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../../rtthread.bin
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: main.c
  group Compiler
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/pin/: dev_pin.c
    ../../../components/drivers/serial/: dev_serial.c
  group Drivers
    ../libraries/HAL_Drivers/drivers/: drv_gpio.c drv_uart.c
    ../libraries/HAL_Drivers/: drv_common.c
    board/: board.c
  group NS800RT7-CMSIS
    packages/novosns-series/NS800RT7XXX/Device/Src/: system_NS800RT7xxx.c
    packages/novosns-series/NS800RT7XXX/Device/Src/iar/: startup_NS800RT7xxx.s
  group NS800RT7-StdDriver
    packages/novosns-series/NS800RT7XXX/StdDriver/Src/: crc.c debug.c flash.c gpio.c interrupt.c rcc.c sram.c syscon.c uart.c xbar.c exti.c dmamux.c edma.c ecap.c flexcan.c
  group Finsh
    ../../../components/finsh/: msh_parse.c shell.c cmd.c msh.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    ../../../src/klibc/: kstring.c kerrno.c kstdio.c rt_vsscanf.c rt_vsnprintf_tiny.c
  group libcpu
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m7/: context_iar.S cpu_cache.c cpuport.c
