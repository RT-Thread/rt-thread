# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: HC32F472PETI HDSC
  pack: HDSC.HC32F472.1.0.0
  cpu: IROM1(0x00000000,0x40000) IROM2(0x03000C00,0x400) IRAM1(0x1FFF8000,0x10000) IRAM2(0x200F0000,0x1000) CPUTYPE("Cortex-M4") FPU2 CLOCK(8000000) ESEL ELITTLE
  output: rt-thread +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: RT_USING_ARMLIBC, __RTTHREAD__, RT_USING_LIBC, __DEBUG, __CLK_TCK=RT_TICK_PER_SECOND, __STDC_LIMIT_MACROS, USE_DDL_DRIVER, HC32F472
  c include: ..\..\..\components\libc\posix\io\epoll;board;..\libraries\hc32f472_ddl\cmsis\Include;..\..\..\components\drivers\include;Include;..\libraries\hc32_drivers;..\..\..\components\libc\posix\ipc;..\libraries\hc32f472_ddl\cmsis\Device\HDSC\hc32f4xx\Include;..\..\..\components\drivers\include;..\..\..\components\libc\posix\io\poll;..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\components\drivers\include;..\..\..\components\finsh;board\ports;..\..\..\components\libc\compilers\common\extension;..\..\..\libcpu\arm\common;..\..\..\components\drivers\smp_call;.;board\config;..\..\..\components\libc\posix\io\eventfd;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\libc\compilers\common\include;..\..\..\include;..\..\..\libcpu\arm\cortex-m4;..\libraries\hc32f472_ddl\hc32_ll_driver\inc;applications;..\..\..\components\drivers\include;..\..\..\components\drivers\phy;packages\hc32-f4-cmsis\Device\HDSC\hc32f472\Include;..\tests;board\config\usb_config;packages\hc32-f4-series\hc32f472\inc;..\platform\tca9539
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x03000C00 size 0x400
  memory RVCT9: RAM 0x1FFF8000 size 0x10000
  memory RVCT10: RAM 0x200F0000 size 0x1000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: xtal32_fcm.c main.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/i2c/: dev_i2c_bit_ops.c dev_i2c_core.c dev_i2c_dev.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/pin/: dev_pin.c
    ../../../components/drivers/serial/: dev_serial.c
  group Drivers
    board/: board.c board_config.c
    ../libraries/hc32f472_ddl/cmsis/Device/HDSC/hc32f4xx/Source/ARM/: startup_hc32f472.s
    ../libraries/hc32_drivers/: drv_common.c drv_gpio.c drv_i2c.c drv_irq.c drv_soft_i2c.c drv_usart.c
  group Finsh
    ../../../components/finsh/: msh_parse.c cmd.c shell.c msh.c
  group HC32F472-LL
    packages/hc32-f4-series/hc32f472/src/: hc32_ll_rmu.c hc32_ll_gpio.c hc32_ll_clk.c hc32_ll_icg.c hc32_ll_fcm.c hc32_ll.c hc32_ll_usart.c hc32_ll_tmr0.c hc32_ll_fcg.c hc32_ll_efm.c hc32_ll_i2c.c hc32_ll_pwc.c hc32_ll_dma.c hc32_ll_utility.c hc32_ll_interrupts.c hc32_ll_aos.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    ../../../src/klibc/: kstring.c kerrno.c rt_vsnprintf_tiny.c rt_vsscanf.c kstdio.c
  group libcpu
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group Libraries
    packages/hc32-f4-cmsis/Device/HDSC/hc32f472/Source/ARM/: startup_hc32f472.s
    packages/hc32-f4-cmsis/Device/HDSC/hc32f472/Source/: system_hc32f472.c
    ../libraries/hc32f472_ddl/cmsis/Device/HDSC/hc32f4xx/Source/: system_hc32f472.c
    ../libraries/hc32f472_ddl/hc32_ll_driver/src/: hc32_ll.c hc32_ll_aos.c hc32_ll_clk.c hc32_ll_dma.c hc32_ll_efm.c hc32_ll_fcg.c hc32_ll_fcm.c hc32_ll_gpio.c hc32_ll_i2c.c hc32_ll_icg.c hc32_ll_interrupts.c hc32_ll_pwc.c hc32_ll_rmu.c hc32_ll_tmr0.c hc32_ll_usart.c hc32_ll_utility.c
  group Platform
    ../platform/tca9539/: tca9539.c
  group Tests
    ../tests/: test_uart_v1.c test_soft_i2c.c test_gpio.c test_i2c.c
