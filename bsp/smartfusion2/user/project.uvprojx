# Keil uVision project project.uvprojx, settings and files
target project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: M2S010 Microsemi
  pack: Microsemi.M2Sxxx.1.0.64
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\user;..\CMSIS;..\CMSIS\startup_arm;..\hal;..\hal\CortexM3;..\hal\CortexM3\Keil;..\libraries\mss_gpio;..\libraries\sys_config;..\libraries\mss_uart;..\..\..\include;..\..\..\include\libc;..\..\..\components\finsh
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group user
    ./: main.c config.c config.h board.c rtconfig.h
  group Libraries
    ../libraries/mss_gpio/: mss_gpio.c
    ../libraries/mss_uart/: mss_uart.c
    ../libraries/sys_config/: sys_config.c
  group hal
    ../HAL/CortexM3/: cortex_nvic.c
    ../HAL/CortexM3/Keil/: hw_reg_access.s hal.s
  group CMSIS
    ../CMSIS/: system_m2sxxx.c core_cm3.c
    ../CMSIS/startup_arm/: startup_m2sxxx.s
  group RT-Thread/Kernel
    ../../../src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c slab.c thread.c timer.c
  group RT-Thread/Libcpu
    ../../../libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
  group RT-Thread/Finsh
    ../../../components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c msh.c msh_file.c shell.c symbol.c
