# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MB9BF506R Fujitsu MB9BF506R
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: __RTTHREAD__
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\components\libc\compilers\common\nogcc; libraries\CMSIS\Include; ..\..\include; drivers; ..\..\components\libc\compilers\common; .; applications; ..\..\examples\utest\testcases\kernel; ..\..\libcpu\arm\cortex-m3; ..\..\components\drivers\include; ..\..\libcpu\arm\common; ..\..\components\finsh; libraries\Device\FUJISTU\MB9BF50x\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: .
  OBJCOPY.OOCOutputFile: project.srec
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: rtthread-mb9bf506.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; __RTTHREAD__
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: startup.c application.c
  group CMSIS
    libraries/Device/FUJISTU/MB9BF50x/Source/: system_mb9bf50x.c
    libraries/Device/FUJISTU/MB9BF50x/Source/IAR/: startup_mb9bf50x.S
  group CPU
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../libcpu/arm/cortex-m3/: context_iar.S cpuport.c
  group DeviceDrivers
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/src/: workqueue.c ringblk_buf.c pipe.c waitqueue.c ringbuffer.c completion.c dataqueue.c
  group Drivers
    drivers/: fm3_uart.c board.c nand.c led.c
  group Finsh
    ../../components/finsh/: shell.c msh.c
  group Kernel
    ../../src/: clock.c kservice.c timer.c irq.c object.c scheduler.c mem.c components.c thread.c memheap.c mempool.c device.c ipc.c idle.c
