# Keil uVision project project.uvprojx, settings and files
target Target 1 (6090000::V6.9::.\ARMCLANG)
  device: XMC7100D-F144K4160:Cortex-M7-0 Infineon
  pack: Infineon.CAT1C_DFP.1.0.0
  cpu: IRAM(0x28000000,0xC0000) IROM(0x10000000,0x410000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: rtthread +hex
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: COMPONENT_MW_CORE_MAKE, CY_USING_HAL, COMPONENT_CAT1, COMPONENT_CAT1C, COMPONENT_MW_RECIPE_MAKE_CAT1C, __CLK_TCK=RT_TICK_PER_SECOND, __STDC_LIMIT_MACROS, COMPONENT_MW_RETARGET_IO, TARGET_APP_KIT_XMC71_EVK_LITE_V2, COMPONENT_SOFTFP, COMPONENT_APP_KIT_XMC71_EVK_LITE_V2, CY_APPNAME_mtb_example_hal_hello_world, CY_SUPPORTS_DEVICE_VALIDATION, RT_USING_ARMLIBC, __RTTHREAD__, COMPONENT_MW_CMSIS, COMPONENT_MW_MTB_PDL_CAT1, COMPONENT_CAT1C4M, DEBUG, COMPONENT_CM7_0, COMPONENT_CM7, COMPONENT_MW_CAT1CM0P, RT_USING_LIBC, COMPONENT_DebugCOMPONENT_GCC_ARM, COMPONENT_MW_CORE_LIB, CORE_NAME_CM7_0=1, XMC7100D_F144K4160, CY_TARGET_BOARD=APP_KIT_XMC71_EVK_LITE_V2, COMPONENT_MW_MTB_HAL_CAT1, COMPONENT_XMC7x_CM0P_SLEEP
  c include: ..\..\..\components\libc\posix\io\eventfd;applications;libs\TARGET_APP_KIT_XMC71_EVK_LITE_V2;..\..\..\components\libc\posix\io\poll;.;packages\Infineon_mtb-hal-cat1-latest\COMPONENT_CAT1C\include\pin_packages;packages\Infineon_cat1cm0p-latest\COMPONENT_CAT1C;packages\Infineon_core-lib-latest\include;..\..\..\libcpu\arm\cortex-m7;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\include;packages\Infineon_mtb-hal-cat1-latest\include_pvt;packages\Infineon_retarget-io-latest;..\..\..\components\libc\posix\ipc;..\..\..\components\drivers\phy;..\..\..\components\libc\compilers\common\include;..\..\..\libcpu\arm\common;..\..\..\components\drivers\include;..\..\..\components\drivers\include;packages\Infineon_mtb-pdl-cat1-latest\drivers\include;..\libraries\HAL_Drivers;..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\components\finsh;packages\Infineon_cmsis-latest\Core\Include;board\ports;packages\Infineon_mtb-pdl-cat1-latest\drivers\third_party\ethernet\include;..\..\..\components\libc\compilers\common\extension;..\libraries\HAL_Drivers\config;libs\TARGET_APP_KIT_XMC71_EVK_LITE_V2\config\GeneratedSource;..\..\..\components\libc\posix\io\epoll;board;packages\Infineon_mtb-pdl-cat1-latest\devices\COMPONENT_CAT1C\include;packages\Infineon_mtb-hal-cat1-latest\include;..\..\..\components\drivers\smp_call;..\..\..\components\drivers\include;packages\Infineon_mtb-hal-cat1-latest\COMPONENT_CAT1C\include\triggers;packages\Infineon_mtb-hal-cat1-latest\COMPONENT_CAT1C\include;packages\Infineon_mtb-pdl-cat1-latest\devices\COMPONENT_CAT1C\include\ip
  memory RVCT4: ROM 0x10000000 size 0x410000
  memory RVCT9: RAM 0x28000000 size 0xc0000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/pin/: dev_pin.c
    ../../../components/drivers/serial/: dev_serial.c
  group Drivers
    board/: board.c
    packages/Infineon_mtb-pdl-cat1-latest/drivers/source/TOOLCHAIN_ARM/: cy_syslib_ext.s
    ../libraries/HAL_Drivers/: drv_common.c drv_gpio.c drv_uart.c
  group Finsh
    ../../../components/finsh/: msh.c msh_parse.c shell.c cmd.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    ../../../src/klibc/: kstdio.c rt_vsscanf.c kstring.c rt_vsnprintf_tiny.c kerrno.c
  group libcpu
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m7/: context_rvds.S cpu_cache.c cpuport.c
  group Libraries
    packages/Infineon_cat1cm0p-latest/COMPONENT_CAT1C/COMPONENT_XMC7x_CM0P_SLEEP/: xmc7100_cm0p_sleep.c xmc7200_cm0p_sleep.c
    packages/Infineon_mtb-hal-cat1-latest/COMPONENT_CAT1C/source/pin_packages/: cyhal_xmc7100_144_teqfp.c
    packages/Infineon_mtb-hal-cat1-latest/COMPONENT_CAT1C/source/triggers/: cyhal_triggers_xmc7100.c
    packages/Infineon_mtb-hal-cat1-latest/source/: cyhal_clock.c cyhal_dma.c cyhal_dma_dmac.c cyhal_dma_dw.c cyhal_gpio.c cyhal_hwmgr.c cyhal_interconnect.c cyhal_irq_impl.c cyhal_lptimer.c cyhal_scb_common.c cyhal_syspm.c cyhal_system.c cyhal_uart.c cyhal_utils.c cyhal_utils_impl.c
    packages/Infineon_mtb-pdl-cat1-latest/devices/COMPONENT_CAT1C/source/: cy_device.c
    packages/Infineon_mtb-pdl-cat1-latest/drivers/source/: cy_dma.c cy_dmac.c cy_gpio.c cy_ipc_drv.c cy_ipc_pipe.c cy_ipc_sema.c cy_mcwdt.c cy_mcwdt_b.c cy_prot.c cy_scb_common.c cy_scb_i2c.c cy_scb_uart.c cy_sysclk.c cy_sysclk_v2.c cy_sysint.c cy_syslib.c cy_syspm.c cy_syspm_v3.c cy_systick.c cy_trigmux.c cy_wdt_b.c
    packages/Infineon_retarget-io-latest/: cy_retarget_io.c
  group libs
    libs/TARGET_APP_KIT_XMC71_EVK_LITE_V2/config/GeneratedSource/: cycfg_clocks.c cycfg_qspi_memslot.c cycfg_system.c cycfg_pins.c cycfg.c
    libs/TARGET_APP_KIT_XMC71_EVK_LITE_V2/COMPONENT_CM7/: startup_cm7.c system_cm7.c
    libs/TARGET_APP_KIT_XMC71_EVK_LITE_V2/: cybsp.c
