# Keil uVision project template.uvprojx, settings and files
target Target_1 (6210000::V6.21::ARMCLANG)
  device: R7FA2A1AB Renesas
  pack: Renesas.RA_DFP.6.0.0
  cpu: CPUTYPE("Cortex-M23")      CLOCK(12000000) ELITTLE
  output: rtthread +hex
  c flags: v6Lang=3 v6LangP=6
  c misc: -ffunction-sections -Wno-license-management -Wunused -Wuninitialized -Wall -Wmissing-declarations -Wpointer-arith -Waggregate-return -Wfloat-equal -Wno-unused-but-set-variable -Wno-implicit-function-declaration -Wno-deprecated-non-prototype -Wno-int-conversion -Oz -D_RENESAS_RA_ -D_RA_CORE=CM23 -D_RA_ORDINAL=1
  asm misc: --via=via/rasc_armasm.via
  scatter file: .\script\fsp.scat
  link misc: --via=via/rasc_armlink.via
  group :Renesas RA Smart Configurator:Common Sources
    ./src/: hal_entry.c
software components: Flex Software:RA Configuration 1.0.0
