# IAR project rt.ewp, settings and files
configuration Debug (RX, debug)
  General.OGChipSelectMenu: R5F562N8 R5F562N8
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.StackSize: 0x100
  General.IStackSize: 0x100
  General.HeapSize: 0x400
  ICCRX.CCDiagSuppress: Pa082,Pa050
  ICCRX.CCIncludePath2: ; RPDL; drivers; ..\..\include; ..\..\components\finsh; ..\..\components\init; ..\..\components\drivers\include; ..\..\libcpu\rx
  ICCRX.IccLang: 0
  ARX.AsmIncludePath: $TOOLKIT_DIR$\INC\
  OBJCOPY.OOCOutputFile: rt.srec
  ILINK.IlinkOutputFile: SCI_Async.out
  ILINK.IlinkIcfFile: F:\Project\IAR\rt\bsp\rx\lnkr5f562n8.icf
  ILINK.IlinkUStackSize: 1
  ILINK.IlinkIStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkAdditionalLibs: RPDL\RX62N_library_LQFP_100.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group RPDL
    RPDL/: interrupt_adc_10.c interrupt_adc_12.c interrupt_bsc.c interrupt_cmt.c interrupt_dmac.c interrupt_exdmac.c interrupt_iic.c Interrupt_INTC.c interrupt_mtu2.c interrupt_not_rpdl.c interrupt_poe.c Interrupt_RTC.c interrupt_sci.c Interrupt_SPI.c Interrupt_TMR.c interrupt_wdt.c
  group rtos/components/drivers
    ../../components/drivers/src/: completion.c dataqueue.c pipe.c portal.c ringbuffer.c workqueue.c
    ../../components/drivers/serial/: serial.c
  group rtos/components/finsh
    ../../components/finsh/: cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_token.c finsh_var.c finsh_vm.c msh.c msh_cmd.c shell.c symbol.c
  group rtos/components/init
    ../../components/init/: components.c
  group rtos/src
    ../../src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c module.c object.c scheduler.c slab.c thread.c timer.c
  group target/app
    applications/: application.c startup.c
  group target/cpu
    ../../libcpu/rx/: context_iar.S cpuport.c
  group target/drivers
    drivers/: board.c uart.c
