# Keil uVision project project.uvprojx, settings and files
target rtthread-lpc55s36 (6160000::V6.16::ARMCLANG)
  device: LPC55S36JBD100 NXP
  pack: NXP.LPC55S36_DFP.13.0.0
  cpu: IRAM(0x10000000,0x03d800) IRAM2(0x20000000,0x01c000) IROM(0x03000000,0x020000) IROM2(0x13000000,0x020000) XRAM(0x04000000,0x4000) XRAM2(0x14000000,0x4000) XRAM3(0x30000000,0x01c000) XROM(0x00000000,0x03d800) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: rtthread
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=3
  c define: __STDC_LIMIT_MACROS, RT_USING_ARMLIBC, RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND, __RTTHREAD__, DEBUG
  c misc: --target=arm-arm-none-eabi
  c include: ..\..\..\components\libc\posix\ipc;..\..\..\components\drivers\include;..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\Libraries\LPC55S36\components\codec;..\Libraries\drivers;board\MCUX_Config\board;..\Libraries\LPC55S36\LPC55S36;..\Libraries\LPC55S36\middleware\sdmmc\inc;.;..\Libraries\CMSIS\Core\Include;..\..\..\components\finsh;..\..\..\components\libc\compilers\common\include;board;..\..\..\libcpu\arm\common;..\..\..\components\libc\posix\io\poll;..\Libraries\LPC55S36\middleware\sdmmc\port;..\..\..\libcpu\arm\cortex-m33;..\..\..\components\drivers\include;..\Libraries\LPC55S36\LPC55S36\drivers;..\..\..\components\libc\posix\io\stdio;applications;..\Libraries\drivers\config;..\..\..\components\libc\compilers\common\extension;..\..\..\components\drivers\include;..\..\..\include
  asm misc: -x assembler-with-cpp
  memory RVCT1: ROM 0x0 size 0x3d800
  memory RVCT4: ROM 0x3000000 size 0x20000
  memory RVCT5: ROM 0x13000000 size 0x20000
  memory RVCT6: RAM 0x4000000 size 0x4000
  memory RVCT7: RAM 0x14000000 size 0x4000
  memory RVCT8: RAM 0x30000000 size 0x1c000
  memory RVCT9: RAM 0x10000000 size 0x3d800
  memory RVCT10: RAM 0x20000000 size 0x1c000
  scatter file: .\board\linker_scripts\LPC55S36_flash.scf
  group Applications
    applications/: main.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdio.c cstdlib.c cstring.c ctime.c cwchar.c
  group CPU
    ../../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m33/: context_rvds.S cpuport.c syscall_rvds.S trustzone.c
  group DeviceDrivers
    ../../../components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/serial/: serial.c
  group Drivers
    board/MCUX_Config/board/: clock_config.c pin_mux.c
    board/: board.c
    ../Libraries/drivers/: drv_key.c drv_led.c drv_pin.c drv_uart.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group Libraries
    ../Libraries/LPC55S36/LPC55S36/drivers/: fsl_usart.c fsl_i2s_dma.c fsl_pint.c fsl_clock.c fsl_power.c fsl_i2c.c fsl_reset.c fsl_usart_dma.c fsl_spi.c fsl_gint.c fsl_wwdt.c fsl_crc.c fsl_anactrl.c fsl_inputmux.c fsl_common.c fsl_utick.c fsl_i2s.c fsl_common_arm.c fsl_sysctl.c fsl_spi_dma.c fsl_cmp.c fsl_flexcomm.c fsl_sctimer.c fsl_lpadc.c fsl_ostimer.c fsl_dma.c fsl_i2c_dma.c fsl_gpio.c fsl_mrt.c fsl_ctimer.c
    ../Libraries/LPC55S36/LPC55S36/arm/: startup_LPC55S36.s
    ../Libraries/LPC55S36/LPC55S36/: system_LPC55S36.c
