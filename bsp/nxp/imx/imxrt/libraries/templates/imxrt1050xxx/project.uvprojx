# Keil uVision project project.uvprojx, settings and files
target rtthread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MIMXRT1052:M7 NXP
  pack: NXP.iMXRT_DFP.1.0.3
  cpu: IRAM(0x20000000,0x00060000) IRAM2(0x00000000,0x00020000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: SKIP_SYSCLK_INIT, XIP_EXTERNAL_FLASH, CPU_MIMXRT1052CVL5B, FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL, EVK_MCIMXRM, RT_USING_ARM_LIBC
  c misc: --library_interface=armcc --library_type=standardlib --diag_suppress=66,1296,186
  c include: .;..\..\..\include;applications;board;board\MCUX_Config;board\ports;..\Libraries\drivers;..\Libraries\drivers\config;..\..\..\libcpu\arm\common;..\..\..\libcpu\arm\cortex-m7;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\finsh;..\..\..\components\libc\compilers\armlibc;..\..\..\components\libc\compilers\common;..\Libraries\MIMXRT1050\CMSIS\Include;..\Libraries\MIMXRT1050\MIMXRT1052;..\Libraries\MIMXRT1050\MIMXRT1052\drivers
  memory RVCT9: RAM 0x20000000 size 0x60000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: .\board\linker_scripts\link.sct
  group Kernel
    ../../../src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group Applications
    applications/: main.c
  group Drivers
    board/: board.c
    board/MCUX_Config/: clock_config.c pin_mux.c
    ../Libraries/drivers/: drv_gpio.c drv_uart.c
  group cpu
    ../../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m7/: cpuport.c context_rvds.S
  group DeviceDrivers
    ../../../components/drivers/clock_time/: clock_time_core.c
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
  group finsh
    ../../../components/finsh/: shell.c symbol.c cmd.c msh.c msh_cmd.c msh_file.c
  group libc
    ../../../components/libc/compilers/armlibc/: libc.c mem_std.c stubs.c time.c
    ../../../components/libc/compilers/common/: gmtime_r.c
  group Libraries
    ../Libraries/MIMXRT1050/MIMXRT1052/: system_MIMXRT1052.c
    ../Libraries/MIMXRT1050/MIMXRT1052/drivers/: fsl_common.c fsl_clock.c fsl_cache.c fsl_gpio.c fsl_lpuart.c fsl_dmamux.c fsl_edma.c fsl_lpuart_edma.c
    ../Libraries/MIMXRT1050/MIMXRT1052/arm/: startup_MIMXRT1052.s
software components: CMSIS:CORE 5.0.2
