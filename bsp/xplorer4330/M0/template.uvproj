# Keil uVision project template.uvproj, settings and files
target LPC4330 SPIFI (ARM-ADS)
  device: LPC4330 CM0 NXP (founded by Philips)
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: rtthread_lpc43xx
  c flags: Optim=1
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT1: ROM 0x14000000 size 0x400000
  memory RVCT9: RAM 0x10000000 size 0x10000
target LPC4330 RAM (ARM-ADS)
  device: LPC4330 CM0 NXP (founded by Philips)
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: rtthread_lpc43xx
  c flags: Optim=1
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT9: RAM 0x10000000 size 0x10000
