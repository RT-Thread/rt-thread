# Keil uVision project KsdkStartupLib_K64F12.uvprojx, settings and files
target KsdkStartupLib_K64F12 Debug (ARM-ADS)
  device: MK64FN1M0xxx12 Freescale
  cpu: CPUTYPE("Cortex-M4.fp")
  output: libksdk_startup.lib (library)
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: DEBUG, CPU_MK64FN1M0VMD12
  c misc: --diag_suppress=66
  c include: ../../../../platform/devices;../../../../platform/devices/MK64F12/include;../../../../platform/devices/MK64F12/startup;../../../../platform/CMSIS/Include;../../../../include
  asm define: DEBUG
  asm misc: --cpreproc_opts '-DDEBUG'
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
  group startup
    ../../../../platform/devices/MK64F12/startup/: system_MK64F12.c
    ../../../../platform/devices/: startup.c startup.h
target KsdkStartupLib_K64F12 Release (ARM-ADS)
  device: MK64FN1M0xxx12 Freescale
  cpu: CPUTYPE("Cortex-M4.fp")
  output: libksdk_startup.lib (library)
  c flags: Optim=4 OneElfS=1
  c define: NDEBUG, CPU_MK64FN1M0VMD12
  c misc: --diag_suppress=66
  c include: as above
  asm define: NDEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x1fff0000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x30000
