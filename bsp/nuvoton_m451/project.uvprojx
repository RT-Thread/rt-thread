# Keil uVision project project.uvprojx, settings and files
target template (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: M451VG6AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.0.5
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: template
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .;applications;drivers;Libraries\Device\Nuvoton\M451Series\Include;Libraries\CMSIS\Include;Libraries\StdDriver\inc;..\..\include;..\..\libcpu\arm\cortex-m4;..\..\libcpu\arm\common;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\finsh
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --keep *.o(FSymTab) --keep *.o(VSymTab)
  group Applications
    applications/: application.c startup.c
  group Drivers
    drivers/: board.c led.c usart.c
  group CMSIS
    Libraries/Device/Nuvoton/M451Series/Source/: system_M451Series.c
    Libraries/Device/Nuvoton/M451Series/Source/ARM/: startup_M451Series.s
  group StdDriver
    Libraries/StdDriver/src/: acmp.c can.c clk.c crc.c dac.c eadc.c ebi.c fmc.c gpio.c i2c.c pdma.c pwm.c rtc.c sc.c scuart.c spi.c sys.c timer.c tk.c uart.c usbd.c wdt.c wwdt.c
  group Kernel
    ../../src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group CORTEX-M4
    ../../libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
  group DeviceDrivers
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/src/: completion.c dataqueue.c pipe.c portal.c ringbuffer.c workqueue.c
  group finsh
    ../../components/finsh/: shell.c symbol.c cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_var.c finsh_vm.c finsh_token.c
