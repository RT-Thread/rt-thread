# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060528::V5.06 update 5 (build 528)::.\ARMCC)
  device: FT32F407VEA2 FMD
  pack: FMD.FT32F4xx_DFP.1.0.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: FT32F407xE, RT_USING_LIBC, __STDC_LIMIT_MACROS, __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND, RT_USING_ARMLIBC
  c include: ..\..\..\components\libc\posix\ipc;..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\libcpu\arm\cortex-m4;..\..\..\components\libc\posix\io\eventfd;..\..\..\components\drivers\include;..\..\..\components\finsh;..\..\..\components\libc\posix\io\poll;..\..\..\components\drivers\include;..\..\..\components\drivers\smp_call;board;..\libraries\Drivers;..\..\..\components\libc\compilers\common\include;..\..\..\components\drivers\phy;..\..\..\components\libc\compilers\common\extension;..\..\..\components\drivers\include;..\libraries\FT32F4xx\FT32F4xx_Driver\inc;..\..\..\components\drivers\include;applications;..\libraries\FT32F4xx\FT32F4xx_Driver\templates\inc;.;..\..\..\include;..\..\..\components\libc\posix\io\epoll;..\..\..\libcpu\arm\common;..\..\..\components\drivers\include;..\libraries\FT32F4xx\CMSIS\FT32F4xx\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    ./applications/: main.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/pin/: dev_pin.c
    ../../../components/drivers/serial/: dev_serial.c
  group Drivers
    ./board/: board.c
    ../libraries/FT32F4xx/CMSIS/FT32F4xx/source/arm/: startup_ft32f407xe.s
    ../libraries/Drivers/: drv_gpio.c drv_usart.c
  group Finsh
    ../../../components/finsh/: cmd.c msh_parse.c shell.c msh.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    ../../../src/klibc/: kstring.c kerrno.c rt_vsnprintf_tiny.c rt_vsscanf.c kstdio.c
  group libcpu
    ../../../libcpu/arm/common/: div0.c showmem.c
    ../../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group Libraries
    ../libraries/FT32F4xx/FT32F4xx_Driver/src/: ft32f4xx_adc.c ft32f4xx_comp.c ft32f4xx_crc.c ft32f4xx_crs.c ft32f4xx_dac.c ft32f4xx_debug.c ft32f4xx_dma.c ft32f4xx_ecap.c ft32f4xx_epwm.c ft32f4xx_eqep.c ft32f4xx_eth.c ft32f4xx_exti.c ft32f4xx_fdcan.c ft32f4xx_flash.c ft32f4xx_fmc.c ft32f4xx_gpio.c ft32f4xx_i2c.c ft32f4xx_i2s.c ft32f4xx_iwdg.c ft32f4xx_lptim.c ft32f4xx_misc.c ft32f4xx_opamp.c ft32f4xx_pwr.c ft32f4xx_qspi.c ft32f4xx_rcc.c ft32f4xx_rng.c ft32f4xx_rtc.c ft32f4xx_sdio.c ft32f4xx_spdif.c ft32f4xx_spi.c ft32f4xx_ssi.c ft32f4xx_syscfg.c ft32f4xx_tim.c ft32f4xx_uart.c ft32f4xx_usart.c ft32f4xx_wwdg.c
    ../libraries/FT32F4xx/CMSIS/FT32F4xx/source/: system_ft32f4xx.c
