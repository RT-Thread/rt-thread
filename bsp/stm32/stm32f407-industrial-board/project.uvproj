# Keil uVision project project.uvproj, settings and files
target rt-thread (ARM-ADS)
  device: STM32F407VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3
  c define: __RTTHREAD__, USE_HAL_DRIVER, RT_USING_ARMLIBC, STM32F407xx, __STDC_LIMIT_MACROS, RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND
  c include: ..\..\..\include;..\..\..\components\libc\compilers\common\extension\fcntl\octal;.;..\..\..\components\drivers\include;..\..\..\components\libc\posix\io\eventfd;packages\stm32f4_hal_driver-latest\Inc;..\..\..\components\drivers\include;..\libraries\HAL_Drivers;packages\stm32f4_cmsis_driver-latest\Include;..\libraries\HAL_Drivers\drivers;..\..\..\components\drivers\smp_call;..\libraries\HAL_Drivers\drivers\config;..\..\..\libcpu\arm\common;..\..\..\components\libc\posix\io\poll;packages\stm32f4_hal_driver-latest\Inc\Legacy;applications;..\..\..\components\libc\compilers\common\include;..\..\..\components\libc\posix\ipc;..\..\..\components\libc\compilers\common\extension;..\..\..\components\drivers\include;..\..\..\components\finsh;board\CubeMX_Config\Inc;..\..\..\components\drivers\include;..\..\..\components\drivers\include;packages\CMSIS-Core-latest\Include;..\..\..\components\drivers\phy;..\..\..\libcpu\arm\cortex-m4;board;..\..\..\components\libc\posix\io\epoll
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/pin/: dev_pin.c
    ../../../components/drivers/serial/: dev_serial.c
  group Drivers
    ../libraries/HAL_Drivers/drivers/: drv_gpio.c drv_usart.c
    ../libraries/HAL_Drivers/: drv_common.c
    board/CubeMX_Config/Src/: stm32f4xx_hal_msp.c
    board/: board.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c cmd.c msh_parse.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    ../../../src/klibc/: kerrno.c rt_vsnprintf_tiny.c rt_vsscanf.c kstdio.c kstring.c
  group libcpu
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group STM32F4-CMSIS
    packages/stm32f4_cmsis_driver-latest/Source/Templates/: system_stm32f4xx.c
    packages/stm32f4_cmsis_driver-latest/Source/Templates/arm/: startup_stm32f407xx.s
  group STM32F4-HAL
    packages/stm32f4_hal_driver-latest/Src/: stm32f4xx_hal_cec.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rcc.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_usart.c stm32f4xx_hal_dma.c stm32f4xx_hal_cryp.c stm32f4xx_hal_uart.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_gpio.c
