# Keil uVision project project.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F072RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x08000000-0x0801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: rt-thread
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: STM32F072xB, USE_HAL_DRIVER
  c include: .;..\..\..\include;applications;.;board;board\CubeMX_Config\Inc;..\libraries\HAL_Drivers;..\libraries\HAL_Drivers\config;..\..\..\libcpu\arm\common;..\..\..\libcpu\arm\cortex-m0;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\finsh;..\libraries\STM32F0xx_HAL\CMSIS\Device\ST\STM32F0xx\Include;..\libraries\STM32F0xx_HAL\STM32F0xx_HAL_Driver\Inc;..\libraries\STM32F0xx_HAL\CMSIS\Include
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\board\linker_scripts\link.sct
  group Kernel
    ../../../src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group Applications
    applications/: main.c
  group Drivers
    board/: board.c
    board/CubeMX_Config/Src/: stm32f0xx_hal_msp.c
    ../libraries/STM32F0xx_HAL/CMSIS/Device/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f072xb.s
    ../libraries/HAL_Drivers/: drv_gpio.c drv_usart.c drv_common.c
  group cpu
    ../../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m0/: cpuport.c context_rvds.S
  group DeviceDrivers
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
  group finsh
    ../../../components/finsh/: shell.c symbol.c cmd.c msh.c msh_cmd.c msh_file.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_var.c finsh_vm.c finsh_token.c
  group STM32_HAL
    ../libraries/STM32F0xx_HAL/CMSIS/Device/ST/STM32F0xx/Source/Templates/: system_stm32f0xx.c
    ../libraries/STM32F0xx_HAL/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_dma.c stm32f0xx_hal_cortex.c stm32f0xx_hal_crc.c stm32f0xx_hal_pwr.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal.c stm32f0xx_ll_crc.c stm32f0xx_ll_dma.c stm32f0xx_ll_exti.c stm32f0xx_ll_gpio.c stm32f0xx_ll_pwr.c stm32f0xx_ll_rcc.c stm32f0xx_ll_utils.c stm32f0xx_hal_gpio.c stm32f0xx_hal_uart.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_usart.c stm32f0xx_ll_usart.c
