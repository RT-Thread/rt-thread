# Keil uVision project project.uvprojx, settings and files
target RT-Thread STM32 (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F207VG STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.4.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rtthread-stm32
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER
  c include: applications;.;Drivers;Libraries\STM32F2xx_StdPeriph_Driver\inc;Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F2xx;..\..\..\..\github\rt-thread\components\CMSIS\Include;Libraries\STM32F2x7_ETH_Driver\inc;..\..\..\..\github\rt-thread\include;..\..\..\..\github\rt-thread\libcpu\arm\cortex-m3;..\..\..\..\github\rt-thread\libcpu\arm\common;..\..\..\..\github\rt-thread\components\drivers\include;..\..\..\..\github\rt-thread\components\drivers\include;..\..\..\..\github\rt-thread\components\finsh;..\..\..\..\github\rt-thread\components\net\lwip-1.4.1\src;..\..\..\..\github\rt-thread\components\net\lwip-1.4.1\src\include;..\..\..\..\github\rt-thread\components\net\lwip-1.4.1\src\include\ipv4;..\..\..\..\github\rt-thread\components\net\lwip-1.4.1\src\arch\include;..\..\..\..\github\rt-thread\components\net\lwip-1.4.1\src\include\netif
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --keep *.o(FSymTab) --keep *.o(VSymTab)
  group Applications
    applications/: application.c startup.c
  group Drivers
    Drivers/: 24LCxx.c FM25Lx.c board.c i2c.c rtc.c stm32f2_eth.c stm32f2xx_it.c usart.c
  group STM32_StdPeriph
    Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F2xx/: system_stm32f2xx.c
    Libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_cryp.c stm32f2xx_cryp_aes.c stm32f2xx_cryp_des.c stm32f2xx_cryp_tdes.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_hash.c stm32f2xx_hash_md5.c stm32f2xx_hash_sha1.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
    Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F2xx/startup/arm/: startup_stm32f2xx.s
    Libraries/STM32F2x7_ETH_Driver/src/: stm32f2x7_eth.c
  group Kernel
    ../../../../github/rt-thread/src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group CORTEX-M3
    ../../../../github/rt-thread/libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
    ../../../../github/rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
  group DeviceDrivers
    ../../../../github/rt-thread/components/drivers/serial/: serial.c
    ../../../../github/rt-thread/components/drivers/src/: completion.c dataqueue.c pipe.c portal.c ringbuffer.c workqueue.c
  group finsh
    ../../../../github/rt-thread/components/finsh/: shell.c symbol.c cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_var.c finsh_vm.c finsh_token.c
  group LwIP
    ../../../../github/rt-thread/components/net/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../../github/rt-thread/components/net/lwip-1.4.1/src/arch/: sys_arch.c
    ../../../../github/rt-thread/components/net/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../../../../github/rt-thread/components/net/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../../../github/rt-thread/components/net/lwip-1.4.1/src/netif/: etharp.c ethernetif.c slipif.c
