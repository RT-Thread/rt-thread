# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: NV32F100FL64E Navota MCU
  pack: Keil.NV32F100_DFP.1.0
  cpu: IRAM(0x1FFFF800,0x2000) IROM(0x00000000,0x20000) IROM2(0x00400000,0x1400) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: rt-thread +hex
  AfterMake: fromelf --bin ".\build\@L.axf" --output ".\build\@L.bin"
  AfterMake: fromelf --text -c ".\build\@L.axf" --output ".\build\@L.txt"
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: INIT_SYSCLK_AT_BOOTING,NV32,KEIL
  c include: .;..\..\components\drivers\include;..\..\components\finsh;..\..\components\init;..\..\include;..\..\libcpu\arm\common;..\..\libcpu\arm\cortex-m0;Libraries\CMSIS\Include;.\Libraries\CMSIS\Navota;.\Libraries\CMSIS\Navota\NV32Series\Include;.\Libraries\CMSIS\Navota\NV32Series;Libraries\StdDriver\inc;applications;drivers
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT5: ROM 0x400000 size 0x1400
  memory RVCT9: RAM 0x1ffff800 size 0x2000
  scatter file: .\navota_nv32f100.sct
  link misc: --keep __fsym_* --keep __vsym_*   --keep __rt_init*
  group Applications
    applications/: application.c startup.c
    ./: rtconfig.h
  group Drivers
    drivers/: board.c led.c usart.c
  group NV32_StdPeriph
    ./Libraries/CMSIS/Navota/NV32Series/Source/ARM/: startup_NV32Series.s
    ./Libraries/CMSIS/Navota/NV32Series/Source/: system_NV32Series.c
    ./Libraries/CMSIS/Navota/: arm_cm0.c
    ./Libraries/StdDriver/src/: nv32f100_acmp.c nv32f100_adc.c nv32f100_crc.c nv32f100_delay.c nv32f100_etm.c nv32f100_flash.c nv32f100_gpio.c nv32f100_i2c.c nv32f100_ics.c nv32f100_kbi.c nv32f100_pit.c nv32f100_pmc.c nv32f100_rtc.c nv32f100_sim.c nv32f100_spi.c nv32f100_uart.c nv32f100_wdog.c
  group Kernel
    ../../src/: clock.c device.c idle.c ipc.c irq.c kservice.c mem.c object.c scheduler.c thread.c timer.c
  group CORTEX-M0
    ../../libcpu/arm/cortex-m0/: cpuport.c context_rvds.S
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
  group DeviceDrivers
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/src/: completion.c dataqueue.c pipe.c portal.c ringbuffer.c workqueue.c
  group finsh
    ../../components/finsh/: shell.c symbol.c cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_var.c finsh_vm.c finsh_token.c
  group Components
    ../../src/: components.c
software components: CMSIS:CORE 5.0.1
