# Keil uVision project template.uvprojx, settings and files
target project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: M2S010 Microsemi
  pack: Microsemi.M2Sxxx.1.0.64
  cpu: IRAM(0x20000000,0x10000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rtthread +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\applications\link.sct
