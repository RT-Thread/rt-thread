# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32WB55RGVx STMicroelectronics
  pack: Keil.STM32WBxx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00040000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_HAL_DRIVER, __CLK_TCK=RT_TICK_PER_SECOND, RT_USING_ARM_LIBC, __RTTHREAD__, STM32WB55xx
  c include: .;applications;..\..\..\libcpu\arm\common;..\..\..\libcpu\arm\cortex-m4;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;board;board\CubeMX_Config\Inc;board\ports;..\libraries\HAL_Drivers;..\libraries\HAL_Drivers\config;..\..\..\components\finsh;.;..\..\..\include;..\..\..\components\libc\compilers\armlibc;..\..\..\components\libc\compilers\common;..\..\..\components\libc\compilers\common\nogcc;..\libraries\STM32WBxx_HAL\STM32WBxx_HAL_Driver\Inc;..\libraries\STM32WBxx_HAL\CMSIS\Device\ST\STM32WBxx\Include;..\libraries\STM32WBxx_HAL\CMSIS\Include;..\..\..\examples\utest\testcases\kernel
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group CPU
    ../../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/src/: pipe.c dataqueue.c ringblk_buf.c ringbuffer.c workqueue.c waitqueue.c completion.c
  group Drivers
    ../libraries/STM32WBxx_HAL/CMSIS/Device/ST/STM32WBxx/Source/Templates/arm/: startup_stm32wb55xx_cm4.s
    board/CubeMX_Config/Src/: stm32wbxx_hal_msp.c
    board/: board.c
    ../libraries/HAL_Drivers/: drv_gpio.c drv_usart.c drv_common.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c cmd.c
  group Kernel
    ../../../src/: components.c kservice.c ipc.c timer.c object.c irq.c mem.c idle.c scheduler.c clock.c mempool.c thread.c device.c
  group libc
    ../../../components/libc/compilers/armlibc/: syscalls.c libc.c mem_std.c
    ../../../components/libc/compilers/common/: time.c stdlib.c
  group Libraries
    ../libraries/STM32WBxx_HAL/STM32WBxx_HAL_Driver/Src/: stm32wbxx_hal_rcc_ex.c stm32wbxx_hal_rcc.c stm32wbxx_hal_hsem.c stm32wbxx_hal_pwr.c stm32wbxx_hal_dma_ex.c stm32wbxx_hal_uart.c stm32wbxx_hal_usart.c stm32wbxx_hal.c stm32wbxx_hal_gpio.c stm32wbxx_hal_cortex.c stm32wbxx_hal_exti.c stm32wbxx_hal_crc_ex.c stm32wbxx_hal_cryp_ex.c stm32wbxx_hal_dma.c stm32wbxx_hal_usart_ex.c stm32wbxx_hal_rng.c stm32wbxx_hal_crc.c stm32wbxx_hal_uart_ex.c stm32wbxx_hal_pwr_ex.c stm32wbxx_hal_cryp.c stm32wbxx_hal_comp.c
    ../libraries/STM32WBxx_HAL/CMSIS/Device/ST/STM32WBxx/Source/Templates/: system_stm32wbxx.c
