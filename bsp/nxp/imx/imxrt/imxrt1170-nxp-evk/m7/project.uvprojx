# Keil uVision project project.uvprojx, settings and files
target rtthread (6150000::V6.15::ARMCLANG)
  device: MIMXRT1176DVMAA:cm7 NXP
  pack: NXP.MIMXRT1176_DFP.13.1.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x20000000,0x040000) IROM(0x00200000,0x040000) XRAM(0x1ffe0000,0x020000) XRAM2(0x00000000,0x040000) XRAM3(0x20240000,0x080000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: rtthread
  c flags: Optim=5 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: CPU_MIMXRT1176DVMAA_cm7, USE_SDRAM, __STDC_LIMIT_MACROS, RT_USING_ARMLIBC, ENDIANNESS, XIP_BOOT_HEADER_DCD_ENABLE=1, ARM_MATH_CM7, RT_USING_LIBC, USE_RTOS, __CLK_TCK=RT_TICK_PER_SECOND, __RTTHREAD__, XIP_BOOT_HEADER_ENABLE=1, FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1, XIP_EXTERNAL_FLASH=1
  c misc: -xc -std=gnu99 -mimplicit-float
  c include: ..\..\..\..\..\..\libcpu\arm\cortex-m7;..\..\..\..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\libraries\MIMXRT1170\MIMXRT1176\drivers\cm7;.;..\..\..\..\..\..\components\libc\compilers\common\include;board\ports;..\..\..\..\..\..\components\drivers\usb\usbhost\include;..\..\..\..\..\..\components\drivers\usb\usbhost\class;..\..\..\..\..\..\components\finsh;xip;..\..\..\..\..\..\components\libc\posix\io\epoll;..\..\..\..\..\..\libcpu\arm\common;..\..\libraries\MIMXRT1170\MIMXRT1176;..\..\..\..\..\..\components\drivers\include;..\..\..\..\..\..\include;..\..\..\..\..\..\components\net\netdev\include;..\..\libraries\MIMXRT1170\MIMXRT1176\drivers;..\..\..\..\..\..\components\libc\posix\io\eventfd;..\..\libraries\drivers;..\..\..\..\..\..\components\drivers\include;..\..\..\..\..\..\components\libc\posix\io\poll;..\..\libraries\MIMXRT1170\CMSIS\Include;..\..\..\..\..\..\components\drivers\include;..\..\..\..\..\..\components\drivers\usb\usbhost\core;..\..\..\..\..\..\components\libc\compilers\common\extension;..\..\..\..\..\..\components\drivers\include;..\..\..\..\..\..\components\drivers\usb\usbhost;..\..\..\..\..\..\components\drivers\include;board;..\..\..\..\..\..\components\libc\posix\ipc;board\MCUX_Config;applications;..\..\..\..\..\..\components\drivers\include
  memory RVCT4: ROM 0x200000 size 0x40000
  memory RVCT6: RAM 0x1ffe0000 size 0x20000
  memory RVCT7: RAM 0x0 size 0x40000
  memory RVCT8: RAM 0x20240000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\board\linker_scripts\link.sct
  link misc: --keep=*(.boot_hdr.ivt) --keep=*(.boot_hdr.boot_data) --keep=*(.boot_hdr.dcd_data) --keep=*(.boot_hdr.conf) --predefine="-DXIP_BOOT_HEADER_ENABLE=1"
  group Applications
    applications/: mnt.c main.c
  group Compiler
    ../../../../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../../../../components/drivers/core/: device.c
    ../../../../../../components/drivers/ipc/: completion.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../../../../components/drivers/phy/: phy.c
    ../../../../../../components/drivers/pin/: pin.c
    ../../../../../../components/drivers/serial/: serial.c
  group Drivers
    board/MCUX_Config/: clock_config.c pin_mux.c
    board/: board.c dcd.c
    ../../libraries/drivers/: drv_common.c drv_gpio.c drv_uart.c drv_usbh.c
    ../../libraries/drivers/usb/host/: usb_host_devices.c usb_host_ehci.c usb_host_framework.c usb_host_hci.c
    ../../libraries/drivers/usb/phy/: usb_phy.c
  group Finsh
    ../../../../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../../../../../src/: clock.c components.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
    ../../../../../../src/klibc/: kstdio.c kstring.c
  group libcpu
    ../../../../../../libcpu/arm/common/: div0.c showmem.c
    ../../../../../../libcpu/arm/cortex-m7/: context_rvds.S cpu_cache.c cpuport.c
  group Libraries
    ../../libraries/MIMXRT1170/MIMXRT1176/drivers/: fsl_pmu.c fsl_lpuart.c fsl_gpio.c fsl_os_abstraction_rtthread.c fsl_anatop_ai.c fsl_dcdc.c fsl_common_arm.c fsl_common.c generic_list.c fsl_clock.c
    ../../libraries/MIMXRT1170/MIMXRT1176/arm/: startup_MIMXRT1176_cm7.s
    ../../libraries/MIMXRT1170/MIMXRT1176/: system_MIMXRT1176_cm7.c
    ../../libraries/MIMXRT1170/MIMXRT1176/drivers/cm7/: fsl_cache.c
  group rt_usbh
    ../../../../../../components/drivers/usb/usbhost/core/: hub.c usbhost.c usbhost_core.c driver.c
  group SAL
    ../../../../../../components/net/netdev/src/: netdev_ipaddr.c netdev.c
  group xip
    xip/: evkmimxrt1170_flexspi_nor_config.c fsl_flexspi_nor_boot.c
