# Keil uVision project project.uvproj, settings and files
target rtthread (ARM-ADS)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.4.1.0
  cpu: CPUTYPE("Cortex-M3") CLOCK(10000000) ESEL ELITTLE
  output: rtthread +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: RT_USING_LIBC, RT_USING_ARMLIBC, __STDC_LIMIT_MACROS, __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND
  c include: ..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\libcpu\arm\cortex-m3;CMSIS\CME_M7;..\..\components\net\lwip\lwip-2.0.3\src\include\posix;..\..\components\net\lwip\lwip-2.0.3\src\include\ipv4;.;StdPeriph_Driver\inc;..\..\components\libc\compilers\common\include;drivers;..\..\components\dfs\dfs_v1\filesystems\elmfat;..\..\components\finsh;..\..\components\libc\posix\io\epoll;..\..\libcpu\arm\common;..\..\components\libc\posix\ipc;..\..\components\drivers\include;..\..\include;CMSIS\CMSIS\Include;..\..\components\libc\posix\io\eventfd;..\..\components\net\lwip\lwip-2.0.3\src\include;..\..\components\net\lwip\port;..\..\components\libc\posix\io\poll;..\..\components\drivers\include;..\..\components\libc\compilers\common\extension;..\..\components\drivers\include;applications;..\..\components\drivers\include;..\..\components\dfs\dfs_v1\include;..\..\components\net\lwip\lwip-2.0.3\src\include\netif
  scatter file: CME_M7.sct
  group Applications
    applications/: led.c startup.c application.c
  group CMSIS
    CMSIS/CME_M7/startup/arm/: startup_cmem7.s
    CMSIS/CME_M7/: system_cmem7.c
  group Compiler
    ../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../components/drivers/core/: device.c
    ../../components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../components/drivers/pin/: pin.c
    ../../components/drivers/serial/: serial.c
  group Drivers
    drivers/: emac.c uart.c board.c app_phy.c
  group Filesystem
    ../../components/dfs/dfs_v1/filesystems/elmfat/: dfs_elm.c ff.c ffunicode.c
    ../../components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    ../../components/finsh/: shell.c msh.c msh_parse.c cmd.c msh_file.c
  group Kernel
    ../../src/: clock.c components.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
    ../../src/klibc/: kstdio.c kstring.c
  group libcpu
    ../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../libcpu/arm/cortex-m3/: context_rvds.S cpuport.c
  group Libraries
    StdPeriph_Driver/src/: cmem7_efuse.c cmem7_eth.c cmem7_flash.c cmem7_adc.c cmem7_i2c.c cmem7_dma.c cmem7_gpio.c cmem7_misc.c cmem7_wdg.c cmem7_rtc.c cmem7_can.c cmem7_tim.c cmem7_spi.c cmem7_ddr.c cmem7_aes.c cmem7_usb.c cmem7_uart.c
  group lwIP
    ../../components/net/lwip/lwip-2.0.3/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../components/net/lwip/lwip-2.0.3/src/apps/ping/: ping.c
    ../../components/net/lwip/lwip-2.0.3/src/core/: def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../components/net/lwip/lwip-2.0.3/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../components/net/lwip/lwip-2.0.3/src/netif/: ethernet.c lowpan6.c
    ../../components/net/lwip/port/: ethernetif.c sys_arch.c
