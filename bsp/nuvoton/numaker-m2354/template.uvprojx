# Keil uVision project template.uvprojx, settings and files
target rtthread-m2354 (6100001::V6.10.1::.\ARMCLANG)
  device: M2354KJFAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.10
  cpu: IRAM(0x20000000,0x40000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M23") TZ CLOCK(12000000) ESEL ELITTLE
  output: rtthread +hex
  AfterMake: fromelf --bin ".\build\keil5\\@L.axf" --output ".\build\keil5\\@L.bin"
  AfterMake: fromelf --text -c ".\build\keil5\\@L.axf" --output ".\build\keil5\\@L.txt"
  c flags: OneElfS=1 v6Lang=5 v6LangP=3 wLevel=1
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  scatter file: .\linking_scripts\m2354_flash.sct
  link misc: --map --first='startup_M2354.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
