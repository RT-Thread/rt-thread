# Keil uVision project project.uvprojx, settings and files
target rt-thread (ARM-ADS)
  device: ES32F0654LT Eastsoft
  pack: Eastsoft.ES32_DFP.1.0.2
  cpu: IRAM(0x20000000,0x00008000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: RT_USING_ARMLIBC, __RTTHREAD__, ES32F065x, RT_USING_LIBC, __STDC_LIMIT_MACROS, __CLK_TCK=RT_TICK_PER_SECOND
  c include: ..\..\..\components\finsh;drivers\ES;..\..\..\components\libc\compilers\common\extension;..\..\..\components\drivers\include;..\..\..\components\libc\posix\ipc;..\..\..\components\drivers\smp_call;..\..\..\components\libc\compilers\common\include;..\..\..\components\libc\posix\io\epoll;..\..\..\components\net\utest;..\..\..\components\libc\posix\io\eventfd;libraries\ES32F065x_ALD_StdPeriph_Driver\Include;..\..\..\components\drivers\include;..\..\..\components\libc\posix\io\poll;..\..\..\components\drivers\phy;..\..\..\libcpu\arm\cortex-m0;..\..\..\libcpu\arm\common;drivers;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;applications;..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\components\drivers\include;..\..\..\include;libraries\CMSIS\Include;libraries\CMSIS\Device\EastSoft\ES32F065x\Include;.
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Applications
    applications/: main.c
  group CPU
    ../../../libcpu/arm/common/: div0.c showmem.c
    ../../../libcpu/arm/cortex-m0/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/pin/: dev_pin.c
    ../../../components/drivers/serial/: dev_serial.c
  group Drivers
    drivers/: board.c drv_gpio.c drv_uart.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group Libc
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../src/klibc/: kerrno.c kstdio.c kstring.c rt_vsnprintf_tiny.c rt_vsscanf.c
  group Libraries
    libraries/ES32F065x_ALD_StdPeriph_Driver/Source/: ald_acmp.c ald_adc.c ald_bkpc.c ald_calc.c ald_can.c ald_cmu.c ald_crc.c ald_crypt.c ald_dma.c ald_flash.c ald_flash_ext.c ald_gpio.c ald_i2c.c ald_iap.c ald_pis.c ald_pmu.c ald_rmu.c ald_rtc.c ald_smartcard.c ald_spi.c ald_timer.c ald_trng.c ald_tsense.c ald_uart.c ald_usart.c ald_wdt.c utils.c
    libraries/CMSIS/Device/EastSoft/ES32F065x/Startup/keil/: startup_es32f065x.s
