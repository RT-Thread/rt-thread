# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F303ZE ST STM32F303ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F303xE; USE_HAL_DRIVER; RT_USING_DLIBC
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\rt-thread\libcpu\arm\cortex-m4; Libraries\CMSIS\Include; ..\rt-thread\components\drivers\include; drivers; ..\rt-thread\components\libc\compilers\dlib; Libraries\CMSIS\Device\ST\STM32F3xx\Include; .; applications; ..\rt-thread\include; ..\rt-thread\components\finsh; Libraries\STM32F3xx_HAL_Driver\Inc; ..\rt-thread\libcpu\arm\common
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: rtthread.bin
  ILINK.IlinkOutputFile: rtthread.out
  ILINK.IlinkIcfFile: stm32_rom.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; STM32F303xE; USE_HAL_DRIVER; RT_USING_DLIBC
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: main.c testled.c
  group Drivers
    drivers/: board.c drv_gpio.c drv_usart.c
  group STM32_HAL
    Libraries/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal.c stm32f3xx_hal_adc.c stm32f3xx_hal_adc_ex.c stm32f3xx_hal_can.c stm32f3xx_hal_cec.c stm32f3xx_hal_comp.c stm32f3xx_hal_cortex.c stm32f3xx_hal_crc.c stm32f3xx_hal_crc_ex.c stm32f3xx_hal_dac.c stm32f3xx_hal_dac_ex.c stm32f3xx_hal_dma.c stm32f3xx_hal_flash.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_hrtim.c stm32f3xx_hal_i2c.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_i2s.c stm32f3xx_hal_i2s_ex.c stm32f3xx_hal_irda.c stm32f3xx_hal_iwdg.c stm32f3xx_hal_nand.c stm32f3xx_hal_nor.c stm32f3xx_hal_opamp.c stm32f3xx_hal_opamp_ex.c stm32f3xx_hal_pccard.c stm32f3xx_hal_pcd.c stm32f3xx_hal_pcd_ex.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_rtc.c stm32f3xx_hal_rtc_ex.c stm32f3xx_hal_sdadc.c stm32f3xx_hal_smartcard.c stm32f3xx_hal_smartcard_ex.c stm32f3xx_hal_smbus.c stm32f3xx_hal_spi.c stm32f3xx_hal_spi_ex.c stm32f3xx_hal_sram.c stm32f3xx_hal_tim.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_tsc.c stm32f3xx_hal_uart.c stm32f3xx_hal_uart_ex.c stm32f3xx_hal_usart.c stm32f3xx_hal_wwdg.c stm32f3xx_ll_adc.c stm32f3xx_ll_comp.c stm32f3xx_ll_crc.c stm32f3xx_ll_dac.c stm32f3xx_ll_dma.c stm32f3xx_ll_exti.c stm32f3xx_ll_fmc.c stm32f3xx_ll_gpio.c stm32f3xx_ll_hrtim.c stm32f3xx_ll_i2c.c stm32f3xx_ll_opamp.c stm32f3xx_ll_pwr.c stm32f3xx_ll_rcc.c stm32f3xx_ll_rtc.c stm32f3xx_ll_spi.c stm32f3xx_ll_tim.c stm32f3xx_ll_usart.c stm32f3xx_ll_utils.c
    Libraries/CMSIS/Device/ST/STM32F3xx/Source/Templates/: system_stm32F3xx.c
    Libraries/CMSIS/Device/ST/STM32F3xx/Source/Templates/iar/: startup_stm32F303xe.s
  group Kernel
    ../rt-thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group CORTEX-M4
    ../rt-thread/libcpu/arm/cortex-m4/: cpuport.c context_iar.S
    ../rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
  group DeviceDrivers
    ../rt-thread/components/drivers/misc/: pin.c
    ../rt-thread/components/drivers/serial/: serial.c
    ../rt-thread/components/drivers/src/: completion.c dataqueue.c pipe.c ringbuffer.c waitqueue.c workqueue.c
  group finsh
    ../rt-thread/components/finsh/: shell.c symbol.c cmd.c msh.c msh_cmd.c msh_file.c
  group dlib
    ../rt-thread/components/libc/compilers/dlib/: environ.c libc.c rmtx.c stdio.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c time.c
