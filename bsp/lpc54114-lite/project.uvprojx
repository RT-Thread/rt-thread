# Keil uVision project project.uvprojx, settings and files
target rtthread-lpc54114 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC54114J256BD64:M4 NXP
  pack: Keil.LPC54000_DFP.2.6.0
  cpu: IRAM(0x20000000,0x00028000) IRAM2(0x04000000,0x00008000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rtthread-lpc54114
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: CPU_LPC54114, CORE_M4, SDK_DEBUGCONSOLE=0, __CLK_TCK=RT_TICK_PER_SECOND, __RTTHREAD__, CPU_LPC54114J256BD64_cm4=1, RT_USING_ARM_LIBC
  c misc: --library_interface=armcc --library_type=standardlib --diag_suppress=66,1296,186
  c include: applications;.;..\..\libcpu\arm\common;..\..\libcpu\arm\cortex-m4;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\drivers\include;..\..\components\drivers\spi;..\..\components\drivers\include;..\..\components\drivers\spi\sfud\inc;..\..\components\drivers\include;drivers;..\..\components\dfs\include;..\..\components\dfs\filesystems\devfs;..\..\components\dfs\filesystems\elmfat;..\..\components\dfs\filesystems\romfs;..\..\components\finsh;.;..\..\include;..\..\components\libc\compilers\armlibc;..\..\components\libc\compilers\common;..\..\components\libc\compilers\common\nogcc;Libraries\CMSIS\Include;Libraries\devices\LPC54114\drivers;Libraries\devices\LPC54114\utilities;Libraries\devices\LPC54114;..\..\examples\utest\testcases\kernel
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x28000
  memory RVCT10: RAM 0x4000000 size 0x8000
  scatter file: .\drivers\linker_scripts\link.scf
  group Applications
    applications/: main.c mnt.c
  group CPU
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
  group DeviceDrivers
    ../../components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    ../../components/drivers/misc/: pin.c
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/spi/sfud/src/: sfud.c
    ../../components/drivers/spi/: spi_flash_sfud.c spi_core.c spi_msd.c spi_dev.c
    ../../components/drivers/src/: dataqueue.c completion.c ringblk_buf.c pipe.c workqueue.c ringbuffer.c waitqueue.c
  group Drivers
    drivers/: drv_sdcard.c drv_gpio.c drv_uart.c drv_spi.c clock_config.c drv_romfs.c drv_i2c.c drv_spi_flash.c board.c
  group Filesystem
    ../../components/dfs/src/: dfs_posix.c dfs_poll.c dfs_file.c dfs.c dfs_fs.c dfs_select.c
    ../../components/dfs/filesystems/devfs/: devfs.c
    ../../components/dfs/filesystems/elmfat/: ff.c ffunicode.c dfs_elm.c
    ../../components/dfs/filesystems/romfs/: dfs_romfs.c romfs.c
  group Finsh
    ../../components/finsh/: shell.c msh.c msh_file.c cmd.c
  group Kernel
    ../../src/: thread.c components.c mempool.c irq.c mem.c clock.c timer.c object.c device.c ipc.c idle.c scheduler.c kservice.c
  group libc
    ../../components/libc/compilers/armlibc/: libc.c stdio.c syscalls.c mem_std.c
    ../../components/libc/compilers/common/: time.c delay.c unistd.c stdlib.c
  group Libraries
    Libraries/devices/LPC54114/drivers/: fsl_i2c.c fsl_dma.c fsl_i2s_dma.c fsl_gint.c fsl_spi_dma.c fsl_utick.c fsl_rtc.c fsl_wwdt.c fsl_dmic_dma.c fsl_gpio.c fsl_i2c_dma.c fsl_dmic.c fsl_common.c fsl_ctimer.c fsl_pint.c fsl_flexcomm.c fsl_spi.c fsl_usart_dma.c fsl_i2s.c fsl_clock.c fsl_power.c fsl_flashiap.c fsl_reset.c fsl_crc.c fsl_fmeas.c fsl_adc.c fsl_mrt.c fsl_inputmux.c fsl_usart.c fsl_sctimer.c
    Libraries/devices/LPC54114/arm/: startup_LPC54114_cm4.s keil_lib_power.lib
    Libraries/devices/LPC54114/: system_LPC54114_cm4.c
