<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\sd_mmc_example1_flash.ewp</path>
	</project>
</workspace>
