# IAR project project.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M481AE series Nuvoton M481AE series (M481AE,M482AE,M483AE,M485AE,M487AE)
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: ARM_MATH_CM4; CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; _DLIB_FILE_DESCRIPTOR; __RTTHREAD__; __RT_IPC_SOURCE__; __RT_KERNEL_SOURCE__
  ICCARM.CCDiagSuppress: Pa082,Pa050
  ICCARM.CCIncludePath2: applications; ..\libraries\m480\Device\Nuvoton\M480\Include; ..\..\..\components\dfs\dfs_v1\include; ..\..\..\components\net\lwip\port; ..\..\..\components\net\lwip\lwip-2.0.3\src\include; ..\..\..\components\net\sal\impl; ..\..\..\components\drivers\sdio\sdhci\include; ..\libraries\m480\CMSIS\Include; ..\..\..\components\drivers\hwcrypto; ..\..\..\components\libc\compilers\common\extension\fcntl\octal; ..\..\..\components\libc\posix\ipc; ..\..\..\components\libc\compilers\common\include; ..\libraries\nu_packages\TPC; ..\..\..\components\net\lwip\lwip-2.0.3\src\include\netif; ..\..\..\components\legacy\usb\usbdevice; ..\..\..\components\drivers\audio; ..\..\..\components\drivers\phy; ..\..\..\libcpu\arm\cortex-m4; .; ..\..\..\components\net\sal\include\socket\sys_socket; ..\..\..\components\net\netdev\include; ..\libraries\m480\USBHostLib\inc; ..\..\..\components\drivers\spi; ..\..\..\components\libc\posix\io\poll; ..\libraries\nu_packages\NuUtils\inc; ..\..\..\include; ..\..\..\components\drivers\spi\sfud\inc; board\NuPinConfig; ..\..\..\components\net\lwip\lwip-2.0.3\src\include\ipv4; ..\..\..\components\net\sal\include; board; ..\..\..\components\net\sal\include\dfs_net; ..\..\..\components\libc\compilers\common\extension; ..\..\..\components\libc\posix\io\eventfd; ..\..\..\components\fal\inc; ..\libraries\m480\StdDriver\inc; ..\..\..\components\legacy\usb\usbhost\class; ..\..\..\components\legacy\usb\usbhost\include; ..\libraries\m480\rtt_port; ..\..\..\components\dfs\dfs_v1\filesystems\elmfat; ..\libraries\nu_packages\AudioCodec; ..\..\..\components\dfs\dfs_v1\filesystems\devfs; ..\..\..\components\legacy\usb\usbhost\core; ..\..\..\components\drivers\smp_call; ..\..\..\components\utilities\utest; ..\..\..\components\libc\posix\io\epoll; ..\..\..\components\legacy\usb\usbhost; ..\..\..\components\finsh; ..\..\..\components\drivers\include; board\NuClockConfig; ..\..\..\components\net\sal\include\socket; ..\..\..\libcpu\arm\common; ..\..\..\components\legacy\include; ..\libraries\nu_packages\Demo
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: rtthread.bin
  ILINK.IlinkOutputFile: Template.out
  ILINK.IlinkIcfFile: linking_scripts\m480_flash.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group Applications
    applications/: main.c mnt.c
  group Compiler
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
    ../../../components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
  group DeviceDrivers
    ../../../components/drivers/audio/: dev_audio.c dev_audio_pipe.c
    ../../../components/drivers/can/: dev_can.c
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/hwcrypto/: hw_crc.c hw_hash.c hw_rng.c hw_symmetric.c hwcrypto.c
    ../../../components/drivers/hwtimer/: hwtimer.c
    ../../../components/drivers/i2c/: dev_i2c_bit_ops.c dev_i2c_core.c dev_i2c_dev.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/misc/: adc.c rt_drv_pwm.c
    ../../../components/drivers/pin/: dev_pin.c
    ../../../components/drivers/pm/: lptimer.c pm.c
    ../../../components/drivers/rtc/: dev_rtc.c
    ../../../components/drivers/sdio/: dev_block.c dev_mmc.c dev_mmcsd_core.c dev_sd.c dev_sdio.c
    ../../../components/drivers/serial/: dev_serial.c
    ../../../components/drivers/spi/: dev_qspi_core.c dev_spi.c dev_spi_core.c dev_spi_flash_sfud.c
    ../../../components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    ../../../components/drivers/watchdog/: dev_watchdog.c
  group Drivers
    ../libraries/m480/Device/Nuvoton/M480/Source/IAR/: startup_M480.s
    ../libraries/m480/Device/Nuvoton/M480/Source/: system_M480.c
    board/NuClockConfig/: nutool_modclkcfg.c
    board/NuPinConfig/: nutool_pincfg.c
    board/: board_dev.c
    ../libraries/m480/rtt_port/: drv_bpwm.c drv_bpwm_capture.c drv_can.c drv_clk.c drv_common.c drv_crc.c drv_crypto.c drv_eadc.c drv_ebi.c drv_ecap.c drv_emac.c drv_epwm.c drv_epwm_capture.c drv_fmc.c drv_gpio.c drv_hsotg.c drv_hsusbd.c drv_i2c.c drv_i2s.c drv_pdma.c drv_qei.c drv_qspi.c drv_rtc.c drv_scuart.c drv_sdh.c drv_sdio.c drv_softi2c.c drv_spi.c drv_spii2s.c drv_timer.c drv_timer_capture.c drv_tpwm.c drv_trng.c drv_uart.c drv_ui2c.c drv_usbd.c drv_usbhost.c drv_uspi.c drv_uuart.c drv_wdt.c
  group Fal
    ../../../components/fal/src/: fal_flash.c fal.c fal_partition.c fal_rtt.c
  group Filesystem
    ../../../components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    ../../../components/dfs/dfs_v1/filesystems/elmfat/: dfs_elm.c ff.c ffunicode.c
    ../../../components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c cmd.c msh_parse.c msh_file.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c signal.c thread.c timer.c
  group klibc
    ../../../src/klibc/: kerrno.c rt_vsnprintf_tiny.c rt_vsscanf.c kstring.c kstdio.c
  group libcpu
    ../../../libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m4/: context_iar.S cpuport.c
  group Libraries
    ../libraries/m480/StdDriver/src/: nu_spi.c nu_scuart.c nu_spim.c nu_bpwm.c nu_rtc.c nu_timer_pwm.c nu_trng.c nu_hsusbd.c nu_clk.c nu_fmc.c nu_sys.c nu_timer.c nu_acmp.c nu_crc.c nu_usbd.c nu_eadc.c nu_sdh.c nu_ebi.c nu_qei.c nu_usci_spi.c nu_wwdt.c nu_pdma.c nu_i2s.c nu_crypto.c nu_uart.c nu_wdt.c nu_ecap.c nu_i2c.c nu_epwm.c nu_ccap.c nu_qspi.c nu_sc.c nu_usci_uart.c nu_dac.c nu_usci_i2c.c nu_can.c nu_gpio.c nu_emac.c
  group lwIP
    ../../../components/net/lwip/lwip-2.0.3/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../components/net/lwip/lwip-2.0.3/src/apps/ping/: ping.c
    ../../../components/net/lwip/lwip-2.0.3/src/core/: def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../components/net/lwip/lwip-2.0.3/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../components/net/lwip/lwip-2.0.3/src/netif/: ethernet.c lowpan6.c
    ../../../components/net/lwip/port/: ethernetif.c sys_arch.c
  group m480_usbhostlib
    ../libraries/m480/USBHostLib/src/: ehci.c mem_alloc.c ehci_iso.c usb_core.c ohci.c
  group nu_pkgs_demo
    ../libraries/nu_packages/Demo/: ccap_demo.c smp_demo.c ccap_saver.c atdev_utils.c usbd_cdc_vcom_echo.c hwsem_counter.c usbd_hid_dance_mouse.c slcd_show_tick.c wormhole_demo.c
  group nu_pkgs_nau88l25
    ../libraries/nu_packages/AudioCodec/: audio_test.c acodec_nau88l25.c
  group rt_usbd
    ../../../components/legacy/usb/usbdevice/core/: usbdevice_core.c usbdevice.c
    ../../../components/legacy/usb/usbdevice/class/: hid.c
  group rt_usbh
    ../../../components/legacy/usb/usbhost/core/: hub.c driver.c usbhost_core.c usbhost.c
    ../../../components/legacy/usb/usbhost/class/: udisk.c mass.c
  group SAL
    ../../../components/net/netdev/src/: netdev.c netdev_ipaddr.c
    ../../../components/net/sal/dfs_net/: dfs_net.c
    ../../../components/net/sal/impl/: af_inet_lwip.c
    ../../../components/net/sal/socket/: net_netdb.c net_sockets.c
    ../../../components/net/sal/src/: sal_socket.c
  group UTest
    ../../../components/utilities/utest/: TC_uassert.c utest.c
