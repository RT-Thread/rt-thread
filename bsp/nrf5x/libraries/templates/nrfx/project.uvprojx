# Keil uVision project project.uvprojx, settings and files
target rtthread (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.38.0
  cpu: IRAM(0x20000000,0x40000) IROM(0x00000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: NRF52840_XXAA, USE_APP_CONFIG, __RTTHREAD__
  c misc: --reduce_paths
  c include: applications;.;..\libraries\cmsis\include;..\..\..\libcpu\arm\common;..\..\..\libcpu\arm\cortex-m4;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;board;..\libraries\drivers;..\..\..\components\finsh;.;..\..\..\include;packages\nrfx-v2.1.0;packages\nrfx-v2.1.0\drivers;packages\nrfx-v2.1.0\drivers\include;packages\nrfx-v2.1.0\mdk;packages\nrfx-v2.1.0\hal
  asm misc: --cpreproc_opts=-DBLE_STACK_SUPPORT_REQD,-DNRF_SD_BLE_API_VERSION=4,-DS132,-DSOFTDEVICE_PRESENT,-DSWI_DISABLE0,-DCONFIG_GPIO_AS_PINRESET,-DNRF52,-DNRF52832_XXAA,-DNRF52_PAN_12,-DNRF52_PAN_15,-DNRF52_PAN_20,-DNRF52_PAN_31,-DNRF52_PAN_36,-DNRF52_PAN_51,-DNRF52_PAN_54,-DNRF52_PAN_55,-DNRF52_PAN_58,-DNRF52_PAN_64,-DNRF52_PAN_74
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Applications
    applications/: application.c
  group CPU
    ../../../libcpu/arm/common/: div0.c backtrace.c showmem.c
    ../../../libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/src/: ringblk_buf.c ringbuffer.c workqueue.c waitqueue.c completion.c pipe.c dataqueue.c
  group Drivers
    board/: board.c
    ../libraries/drivers/: drv_uart.c
  group finsh
    ../../../components/finsh/: shell.c msh.c cmd.c
  group Kernel
    ../../../src/: irq.c clock.c kservice.c timer.c object.c components.c scheduler.c idle.c ipc.c mem.c thread.c mempool.c device.c
  group nrfx
    packages/nrfx-v2.1.0/drivers/src/: nrfx_spim.c nrfx_pwm.c nrfx_spi.c nrfx_saadc.c nrfx_usbd.c nrfx_nvmc.c nrfx_comp.c nrfx_clock.c nrfx_twi_twim.c nrfx_uart.c nrfx_temp.c nrfx_twis.c nrfx_ipc.c nrfx_adc.c nrfx_dppi.c nrfx_usbreg.c nrfx_systick.c nrfx_spis.c nrfx_uarte.c nrfx_gpiote.c nrfx_timer.c nrfx_qspi.c nrfx_pdm.c nrfx_rng.c nrfx_lpcomp.c nrfx_i2s.c nrfx_power.c nrfx_ppi.c nrfx_egu.c nrfx_rtc.c nrfx_twi.c nrfx_wdt.c nrfx_nfct.c nrfx_qdec.c nrfx_twim.c
    packages/nrfx-v2.1.0/mdk/: arm_startup_nrf52840.s system_nrf52840.c
