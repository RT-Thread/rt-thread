# Keil uVision project project.uvprojx, settings and files
target rtthread-m031 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: M032KIAAE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.10
  cpu: IRAM(0x20000000,0x18000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: rtthread +hex
  AfterMake: fromelf --bin ".\build\keil5\\@L.axf" --output ".\build\keil5\\@L.bin"
  AfterMake: fromelf --text -c ".\build\keil5\\@L.axf" --output ".\build\keil5\\@L.txt"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=1
  c define: __CLK_TCK=RT_TICK_PER_SECOND, RT_USING_ARMLIBC, __RTTHREAD__, __STDC_LIMIT_MACROS, RT_USING_LIBC
  c include: ..\..\..\components\libc\compilers\common\extension\fcntl\octal;..\..\..\components\drivers\phy;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\libraries\m031\CMSIS\Include;..\..\..\components\libc\posix\io\epoll;..\..\..\components\drivers\include;.;..\..\..\components\drivers\include;..\..\..\examples\utest\testcases\kernel\smp;..\..\..\examples\utest\testcases\mm;..\..\..\examples\utest\testcases\drivers\ipc;..\..\..\components\drivers\include;..\..\..\examples\utest\testcases\smp_call;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\examples\utest\testcases\lwp;..\..\..\components\libc\posix\ipc;..\..\..\components\libc\posix\io\poll;..\libraries\nu_packages\Demo;..\..\..\components\libc\posix\io\eventfd;applications;board;..\..\..\examples\utest\testcases\tmpfs;..\libraries\m031\rtt_port;..\..\..\examples\utest\testcases\kernel;..\..\..\components\drivers\smp_call;..\..\..\components\dfs\dfs_v1\include;..\..\..\components\libc\compilers\common\include;..\libraries\m031\Device\Nuvoton\M031\Include;..\..\..\components\legacy\usb\usbdevice;..\..\..\examples\utest\testcases\utest;..\..\..\components\drivers\include;..\..\..\libcpu\arm\cortex-m0;..\..\..\components\utilities\utest;..\..\..\components\drivers\include;..\..\..\components\dfs\dfs_v1\filesystems\devfs;..\libraries\m031\StdDriver\inc;..\libraries\nu_packages\NuUtils\inc;board\NuPinConfig;..\..\..\components\libc\compilers\common\extension;..\..\..\components\drivers\include;..\..\..\components\finsh;..\..\..\include;..\libraries\nu_packages\TPC;..\..\..\libcpu\arm\common;board\NuClockConfig
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  scatter file: .\linking_scripts\m031_flash.sct
  group Applications
    applications/: mnt.c main.c
  group board
    board/NuClockConfig/: nutool_modclkcfg.c
    board/: board_dev.c
    board/NuPinConfig/: nutool_pincfg.c
  group Compiler
    ../../../components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../../../components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../../../components/drivers/core/: device.c
    ../../../components/drivers/hwtimer/: hwtimer.c
    ../../../components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/misc/: adc.c rt_drv_pwm.c
    ../../../components/drivers/pin/: dev_pin.c
    ../../../components/drivers/pm/: lptimer.c pm.c
    ../../../components/drivers/rtc/: dev_rtc.c
    ../../../components/drivers/serial/: dev_serial.c
    ../../../components/drivers/watchdog/: dev_watchdog.c
  group Drivers
    ../libraries/m031/Device/Nuvoton/M031/Source/ARM/: startup_M031Series.s
    ../libraries/m031/Device/Nuvoton/M031/Source/: system_M031Series.c
    ../libraries/m031/rtt_port/: drv_adc.c drv_bpwm.c drv_bpwm_capture.c drv_clk.c drv_common.c drv_crc.c drv_crypto.c drv_ebi.c drv_fmc.c drv_gpio.c drv_i2c.c drv_pdma.c drv_pwm.c drv_pwm_capture.c drv_qspi.c drv_rtc.c drv_softi2c.c drv_spi.c drv_spii2s.c drv_timer.c drv_timer_capture.c drv_uart.c drv_ui2c.c drv_usbd.c drv_uspi.c drv_uuart.c drv_wdt.c
  group Filesystem
    ../../../components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    ../../../components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    ../../../components/finsh/: cmd.c msh_parse.c msh_file.c msh.c shell.c
  group Kernel
    ../../../src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    ../../../src/klibc/: rt_vsnprintf_tiny.c rt_vsscanf.c kstdio.c kstring.c kerrno.c
  group libcpu
    ../../../libcpu/arm/common/: div0.c showmem.c
    ../../../libcpu/arm/cortex-m0/: context_rvds.S cpuport.c
  group Libraries
    ../libraries/m031/StdDriver/src/: nu_pdma.c nu_gpio.c nu_crc.c nu_pwm.c nu_ebi.c nu_usci_spi.c nu_usci_uart.c nu_usci_i2c.c nu_wwdt.c nu_clk.c nu_i2c.c nu_acmp.c nu_qspi.c nu_adc.c nu_rtc.c nu_wdt.c nu_sys.c nu_fmc.c nu_timer.c nu_uart.c nu_bpwm.c nu_usbd.c nu_spi.c
  group nu_pkgs_demo
    ../libraries/nu_packages/Demo/: usbd_cdc_vcom_echo.c slcd_show_tick.c ccap_demo.c usbd_hid_dance_mouse.c ccap_saver.c atdev_utils.c wormhole_demo.c hwsem_counter.c smp_demo.c
  group rt_usbd
    ../../../components/legacy/usb/usbdevice/class/: hid.c
    ../../../components/legacy/usb/usbdevice/core/: usbdevice.c usbdevice_core.c
  group UTest
    ../../../components/utilities/utest/: utest.c TC_uassert.c
  group utestcases
    ../../../examples/utest/testcases/kernel/: mem_tc.c
    ../../../examples/utest/testcases/utest/: pass_tc.c
