# Keil uVision project project.uvprojx, settings and files
target rt-thread_gd32f4xx (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: GD32F450ZK GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.1.0.1
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0300000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rtthread-gd32f4xx
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: GD32F4XX, USE_STDPERIPH_DRIVER
  c include: applications;.;drivers;Libraries\CMSIS\GD\GD32F4xx\Include;Libraries\CMSIS;Libraries\GD32F4xx_standard_peripheral\Include;..\..\..\git\rt-thread\include;..\..\..\git\rt-thread\libcpu\arm\cortex-m4;..\..\..\git\rt-thread\libcpu\arm\common;..\..\..\git\rt-thread\components\dfs\include;..\..\..\git\rt-thread\components\dfs\filesystems\devfs;..\..\..\git\rt-thread\components\dfs\filesystems\elmfat;..\..\..\git\rt-thread\components\drivers\include;..\..\..\git\rt-thread\components\drivers\include;..\..\..\git\rt-thread\components\drivers\include;..\..\..\git\rt-thread\components\drivers\spi;..\..\..\git\rt-thread\components\drivers\include;..\..\..\git\rt-thread\components\drivers\spi\sfud\inc;..\..\..\git\rt-thread\components\drivers\include;..\..\..\git\rt-thread\components\finsh;..\..\..\git\rt-thread\components\gui\include;..\..\..\git\rt-thread\components\net\lwip-1.4.1\src;..\..\..\git\rt-thread\components\net\lwip-1.4.1\src\include;..\..\..\git\rt-thread\components\net\lwip-1.4.1\src\include\ipv4;..\..\..\git\rt-thread\components\net\lwip-1.4.1\src\arch\include;..\..\..\git\rt-thread\components\net\lwip-1.4.1\src\include\netif;..\..\..\git\rt-thread\components\trace;..\..\..\git\rt-thread\components\trace\SystemView_Src_V240\Config;..\..\..\git\rt-thread\components\trace;..\..\..\git\rt-thread\components\trace\SystemView_Src_V240\SEGGER
  memory RVCT4: ROM 0x8000000 size 0x300000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --keep *.o(RTMSymTab)  --keep *.o(.rti_fn.*)   --keep *.o(FSymTab) --keep *.o(VSymTab)
  group Applications
    applications/: application.c rtgui_demo.c startup.c
  group Drivers
    drivers/: board.c drv_exmc_sdram.c drv_usart.c drv_enet.c synopsys_emac.c drv_lcd.c gd32f450z_lcd_eval.c drv_spi_flash.c drv_spi.c
  group GD32_Lib
    Libraries/GD32F4xx_standard_peripheral/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
    Libraries/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
    Libraries/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f4xx.s
  group Kernel
    ../../../git/rt-thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c module.c object.c scheduler.c thread.c timer.c
  group CORTEX-M4
    ../../../git/rt-thread/libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
    ../../../git/rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
  group Filesystem
    ../../../git/rt-thread/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
    ../../../git/rt-thread/components/dfs/filesystems/devfs/: console.c devfs.c
    ../../../git/rt-thread/components/dfs/filesystems/elmfat/: dfs_elm.c ff.c
  group DeviceDrivers
    ../../../git/rt-thread/components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    ../../../git/rt-thread/components/drivers/rtc/: rtc.c
    ../../../git/rt-thread/components/drivers/serial/: serial.c
    ../../../git/rt-thread/components/drivers/spi/: spi_core.c spi_dev.c spi_flash_sfud.c
    ../../../git/rt-thread/components/drivers/spi/sfud/src/: sfud.c
    ../../../git/rt-thread/components/drivers/src/: completion.c dataqueue.c pipe.c portal.c ringbuffer.c workqueue.c
  group finsh
    ../../../git/rt-thread/components/finsh/: shell.c symbol.c cmd.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_var.c finsh_vm.c finsh_token.c
  group GUIEngine
    ../../../git/rt-thread/components/gui/src/: asc12font.c asc16font.c blit.c box.c color.c container.c dc.c dc_blend.c dc_buffer.c dc_client.c dc_hw.c dc_rotozoom.c dc_trans.c filerw.c font.c font_bmp.c font_fnt.c font_freetype.c font_hz_bmp.c font_hz_file.c hz12font.c hz16font.c image.c image_bmp.c image_hdc.c image_jpg.c image_png.c image_xpm.c matrix.c mouse.c region.c rtgui_app.c rtgui_driver.c rtgui_object.c rtgui_system.c server.c title.c topwin.c widget.c window.c
  group LwIP
    ../../../git/rt-thread/components/net/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../git/rt-thread/components/net/lwip-1.4.1/src/arch/: sys_arch.c
    ../../../git/rt-thread/components/net/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../../../git/rt-thread/components/net/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../../git/rt-thread/components/net/lwip-1.4.1/src/netif/: etharp.c ethernetif.c slipif.c
  group trace
    ../../../git/rt-thread/components/trace/SystemView_Src_V240/Config/: SEGGER_SYSVIEW_Config_RTThread.c SEGGER_SYSVIEW_RTThread.c
    ../../../git/rt-thread/components/trace/SystemView_Src_V240/SEGGER/: SEGGER_RTT.c SEGGER_SYSVIEW.c
software components: CMSIS:CORE 5.0.1
