# IAR project project.ewp, settings and files
configuration rtthread (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1062xxx6A NXP MIMXRT1062xxx6A
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; _DLIB_FILE_DESCRIPTOR; CPU_MIMXRT1062DVL6A; SKIP_SYSCLK_INIT; EVK_MCIMXRM; FSL_SDK_ENABLE_DRIVER_CACHE_CONTROL=1; FSL_SDK_DRIVER_QUICK_ACCESS_ENABLE=1; DATA_SECTION_IS_CACHEABLE=0; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; ENDIANNESS; USE_RTOS; __RTTHREAD__
  ICCARM.CCDiagSuppress: Pa082,Pa050,Pe167
  ICCARM.CCIncludePath2: ..\..\..\components\dfs\filesystems\devfs; ..\..\..\components\finsh; board\MCUX_Config; ..\..\..\components\net\lwip\lwip-2.0.3\src\include\posix; ..\..\..\components\drivers\include; ..\libraries\MIMXRT1060\MIMXRT1060\drivers; ..\..\..\components\net\lwip\lwip-2.0.3\src\include\netif; ..\..\..\components\libc\compilers\common\extension; ..\..\..\components\drivers\usb\usbhost\core; ..\..\..\components\net\lwip\lwip-2.0.3\src\include; ..\..\..\components\libc\posix\ipc; ..\..\..\components\dfs\include; ..\..\..\components\libc\posix\io\stdio; ..\libraries\drivers; ..\..\..\components\drivers\usb\usbhost\include; ..\libraries\MIMXRT1060\CMSIS\Include; .; xip; ..\..\..\components\utilities\libadt; board; ..\..\..\components\drivers\usb\usbhost; ..\..\..\components\libc\compilers\common\extension\fcntl\octal; ..\..\..\components\libc\compilers\common\include; board\ports; ..\..\..\components\drivers\usb\usbhost\class; applications; ..\libraries\MIMXRT1060\MIMXRT1060; ..\..\..\components\net\lwip\port; ..\..\..\components\dfs\filesystems\elmfat; ..\..\..\components\libc\posix\io\poll; ..\..\..\include; ..\..\..\libcpu\arm\common; ..\..\..\libcpu\arm\cortex-m7; ..\..\..\components\net\netdev\include; ..\..\..\components\net\lwip\lwip-2.0.3\src\include\ipv4
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: template.srec
  ILINK.IlinkOutputFile: rtthread.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group ADT
    ../../../components/utilities/libadt/: avl.c
  group Applications
    applications/: mnt.c main.c
  group Compiler
    ../../../components/libc/compilers/common/: cctype.c cstdio.c cstdlib.c cstring.c ctime.c cwchar.c
    ../../../components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
  group CPU
    ../../../libcpu/arm/common/: div0.c showmem.c
    ../../../libcpu/arm/cortex-m7/: context_iar.S cpu_cache.c cpuport.c
  group DeviceDrivers
    ../../../components/drivers/i2c/: i2c-bit-ops.c i2c_core.c i2c_dev.c
    ../../../components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/phy/: phy.c
    ../../../components/drivers/sdio/: block_dev.c gpt.c mmc.c mmcsd_core.c sd.c sdio.c
    ../../../components/drivers/serial/: serial.c
  group Drivers
    board/MCUX_Config/: clock_config.c dcd.c pin_mux.c
    board/: board.c
    ../libraries/drivers/: drv_common.c drv_eth.c drv_gpio.c drv_ksz8081.c drv_mdio.c drv_sdio.c drv_sdram.c drv_uart.c drv_usbh.c
    ../libraries/drivers/usb/host/: usb_host_devices.c usb_host_ehci.c usb_host_framework.c usb_host_hci.c
    ../libraries/drivers/usb/phy/: usb_phy.c
  group Filesystem
    ../../../components/dfs/filesystems/devfs/: devfs.c
    ../../../components/dfs/filesystems/elmfat/: dfs_elm.c ff.c ffunicode.c
    ../../../components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c msh_parse.c cmd.c msh_file.c
  group Kernel
    ../../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler.c thread.c timer.c
  group Libraries
    ../libraries/MIMXRT1060/MIMXRT1060/drivers/: fsl_lpuart.c fsl_xbara.c fsl_clock.c fsl_usdhc.c fsl_gpio.c fsl_xbarb.c fsl_enet.c fsl_common.c fsl_semc.c fsl_os_abstraction_rtthread.c fsl_cache.c fsl_common_arm.c generic_list.c
    ../libraries/MIMXRT1060/MIMXRT1060/: system_MIMXRT1062.c
    ../libraries/MIMXRT1060/MIMXRT1060/iar/: startup_MIMXRT1062.s
  group lwIP
    ../../../components/net/lwip/lwip-2.0.3/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../components/net/lwip/lwip-2.0.3/src/apps/ping/: ping.c
    ../../../components/net/lwip/lwip-2.0.3/src/core/: def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../../components/net/lwip/lwip-2.0.3/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../../components/net/lwip/lwip-2.0.3/src/netif/: ethernet.c lowpan6.c
    ../../../components/net/lwip/port/: ethernetif.c sys_arch.c
  group rt_usbh
    ../../../components/drivers/usb/usbhost/core/: hub.c usbhost.c usbhost_core.c driver.c
    ../../../components/drivers/usb/usbhost/class/: udisk.c mass.c
  group SAL
    ../../../components/net/netdev/src/: netdev.c netdev_ipaddr.c
  group xip
    xip/: evkmimxrt1060_flexspi_nor_config.c fsl_flexspi_nor_boot.c
