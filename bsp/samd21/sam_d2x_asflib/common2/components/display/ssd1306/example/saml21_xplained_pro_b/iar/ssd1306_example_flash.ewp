# IAR project ssd1306_example_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAML21J18B Atmel ATSAML21J18B
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ARM_MATH_CM0PLUS=true; BOARD=SAML21_XPLAINED_PRO; SPI_CALLBACK_MODE=true; __SAML21J18B__; SYSTICK_MODE
  ICCARM.CCIncludePath2: ../../../../../../../sam0/drivers/system/power; ../../../../../../../sam0/drivers/system/reset; ../../../../../../../sam0/utils/preprocessor; ../../../../../../../sam0/boards/saml21_xplained_pro_b; ../../../../../../services/delay; ../../../../../../../sam0/drivers/sercom/spi; ../../../../../../../sam0/utils; ../../../../../../../sam0/drivers/sercom; ../../../../../../../sam0/drivers/port; ../../../../../../../sam0/boards; ../../../../../../../sam0/utils/cmsis/saml21/include_b; ../../..; ../../../../../../../common/utils; ../../../../../../../sam0/drivers/system/interrupt; ../../../../../../../sam0/drivers/system/power/power_sam_l; ..; ../../../../../../../sam0/drivers/system/interrupt/system_interrupt_saml21; ../../../../../../services/delay/sam0; ../../../../../../../sam0/drivers/system/clock/clock_saml21; ../../../../../../../common/boards; ../../../../../../../sam0/drivers/system/reset/reset_sam_l; ../../../../../../../sam0/drivers/system/pinmux; ../../../../../../../sam0/drivers/system; ../../../../../../../sam0/utils/cmsis/saml21/source; ../../../../../../../sam0/utils/header_files; ../../../../../../../sam0/drivers/system/clock; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: ssd1306_example_flash.bin
  ILINK.IlinkOutputFile: ssd1306_example_flash.out
  ILINK.IlinkIcfFile: ../../../../../../../sam0/utils/linker_scripts/saml21/iar/saml21j18b_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common2/components/display/ssd1306
    ../../../: ssd1306.c ssd1306.h
  group common2/components/display/ssd1306/example
    ../../: ssd1306_example.c
  group common2/components/display/ssd1306/example/saml21_xplained_pro_b
    ../: conf_board.h conf_ssd1306.h conf_spi.h conf_clocks.h
  group common2/components/display/ssd1306/example/saml21_xplained_pro_b/iar
    ./: asf.h
  group common2/services/delay
    ../../../../../../services/delay/: delay.h
  group common2/services/delay/sam0
    ../../../../../../services/delay/sam0/: systick_counter.c systick_counter.h
  group sam0/boards/saml21_xplained_pro_b
    ../../../../../../../sam0/boards/saml21_xplained_pro_b/: board_init.c saml21_xplained_pro.h
  group sam0/drivers/system
    ../../../../../../../sam0/drivers/system/: system.c system.h
  group sam0/drivers/system/clock
    ../../../../../../../sam0/drivers/system/clock/: clock.h gclk.h
  group sam0/drivers/system/clock/clock_saml21
    ../../../../../../../sam0/drivers/system/clock/clock_saml21/: gclk.c clock.c clock_feature.h clock_config_check.h
  group sam0/drivers/system/interrupt
    ../../../../../../../sam0/drivers/system/interrupt/: system_interrupt.c system_interrupt.h
  group sam0/drivers/system/interrupt/system_interrupt_saml21
    ../../../../../../../sam0/drivers/system/interrupt/system_interrupt_saml21/: system_interrupt_features.h
  group sam0/drivers/system/pinmux
    ../../../../../../../sam0/drivers/system/pinmux/: pinmux.c pinmux.h
  group sam0/drivers/system/pinmux/quick_start
    ../../../../../../../sam0/drivers/system/pinmux/quick_start/: qs_pinmux_basic.h
  group sam0/drivers/system/power/power_sam_l
    ../../../../../../../sam0/drivers/system/power/power_sam_l/: power.h
  group sam0/drivers/system/reset/reset_sam_l
    ../../../../../../../sam0/drivers/system/reset/reset_sam_l/: reset.h
  group sam0/drivers/port
    ../../../../../../../sam0/drivers/port/: port.c port.h
  group sam0/drivers/port/quick_start
    ../../../../../../../sam0/drivers/port/quick_start/: qs_port_basic.h
  group sam0/drivers/sercom
    ../../../../../../../sam0/drivers/sercom/: sercom_interrupt.c sercom.c sercom_pinout.h sercom.h sercom_interrupt.h
  group sam0/drivers/sercom/spi
    ../../../../../../../sam0/drivers/sercom/spi/: spi_interrupt.c spi.c spi.h spi_interrupt.h
  group sam0/drivers/sercom/spi/quick_start_slave
    ../../../../../../../sam0/drivers/sercom/spi/quick_start_slave/: qs_spi_slave_basic.h
  group sam0/drivers/sercom/spi/quick_start_slave_callback
    ../../../../../../../sam0/drivers/sercom/spi/quick_start_slave_callback/: qs_spi_slave_callback.h
  group sam0/drivers/sercom/spi/quick_start_dma
    ../../../../../../../sam0/drivers/sercom/spi/quick_start_dma/: qs_spi_dma_use.h
  group sam0/drivers/sercom/spi/quick_start_master
    ../../../../../../../sam0/drivers/sercom/spi/quick_start_master/: qs_spi_master_basic.h
  group sam0/drivers/sercom/spi/quick_start_master_callback
    ../../../../../../../sam0/drivers/sercom/spi/quick_start_master_callback/: qs_spi_master_callback.h
  group sam0/utils
    ../../../../../../../sam0/utils/: compiler.h status_codes.h
  group sam0/utils/cmsis/saml21/source
    ../../../../../../../sam0/utils/cmsis/saml21/source/: system_saml21.c system_saml21.h
  group sam0/utils/cmsis/saml21/source/iar
    ../../../../../../../sam0/utils/cmsis/saml21/source/iar/: startup_saml21.c
  group sam0/utils/cmsis/saml21/include_b
    ../../../../../../../sam0/utils/cmsis/saml21/include_b/: saml21e15b.h saml21g17b.h saml21j17b.h saml21j18b.h saml21g18b.h saml21e18b.h saml21g16b.h saml21j16b.h saml21.h saml21e16b.h saml21e17b.h
  group sam0/utils/cmsis/saml21/include_b/instance
    ../../../../../../../sam0/utils/cmsis/saml21/include_b/instance/: gclk.h ccl.h sercom5.h dsu.h tcc1.h oscctrl.h sercom0.h dmac.h sercom3.h mtb.h osc32kctrl.h pac.h eic.h tc1.h usb.h sercom4.h tc3.h rstc.h trng.h sercom2.h rtc.h ac.h tc0.h port.h pm.h tc2.h tc4.h dac.h wdt.h tal.h supc.h tcc2.h evsys.h opamp.h sercom1.h tcc0.h adc.h nvmctrl.h aes.h mclk.h
  group sam0/utils/cmsis/saml21/include_b/component
    ../../../../../../../sam0/utils/cmsis/saml21/include_b/component/: opamp.h pm.h trng.h oscctrl.h port.h wdt.h mtb.h pac.h dsu.h dac.h mclk.h usb.h tal.h dmac.h adc.h supc.h gclk.h evsys.h ac.h rtc.h rstc.h sercom.h osc32kctrl.h aes.h ccl.h tc.h tcc.h eic.h nvmctrl.h
  group sam0/utils/cmsis/saml21/include_b/pio
    ../../../../../../../sam0/utils/cmsis/saml21/include_b/pio/: saml21e16b.h saml21j17b.h saml21g18b.h saml21e15b.h saml21e17b.h saml21g17b.h saml21g16b.h saml21e18b.h saml21j16b.h saml21j18b.h
  group sam0/utils/preprocessor
    ../../../../../../../sam0/utils/preprocessor/: mrepeat.h mrecursion.h tpaste.h preprocessor.h stringz.h
  group sam0/utils/header_files
    ../../../../../../../sam0/utils/header_files/: io.h
  group common/utils
    ../../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/interrupt
    ../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../../common/boards/: board.h
