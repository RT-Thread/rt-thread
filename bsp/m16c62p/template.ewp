# IAR project template.ewp, settings and files
configuration Debug (M16C, debug)
  General.GData16HeapSize: 0x400
  General.GFarHeapSize: 0x400
  General.GData20HeapSize: 0x400
  General.GStackSize: 0x80
  General.GIStackSize: 0x40
  General.OGChipSelectMenu: M30627FHP M30627FHP
  ICCM16C.CCDiagSuppress: Pa050
  ICCM16C.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  ICCM16C.IccLang: 0
  XLINK.XclFile: lnkm30627fhp.xcl
  XLINK.XlinkStackSize: 1
  XLINK.XlinkInterruptStackSize: 1
configuration Release (M16C)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  XLINK.XclFile: lnk0t.xcl
