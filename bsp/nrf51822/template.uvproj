# Keil uVision project template.uvproj, settings and files
target rt-thread (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.1.1.4
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: template
  c flags: Optim=1 OneElfS=1
  c define: NRF51 DEBUG_NRF_USER BLE_STACK_SUPPORT_REQD ENABLE_DEBUG_LOG_SUPPORT BOARD_WATCH1000
  c misc: --c99
  memory RVCT4: ROM 0x16000 size 0x2a000
  memory RVCT9: RAM 0x20002000 size 0x2000
